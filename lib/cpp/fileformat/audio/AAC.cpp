// ASCII C/C++ TAB4 CRLF
// Docutitle: [Filefmt.Audio] MPEG-4 Advanced Audio Coding (AAC-LC) Codec Implementation
// Attribute: Env-Freestanding Non-Dependence
// Copyright: UNISYM
//
// License: Apache-2.0 (see LICENSE); copyright only. AAC is covered by third-party patents -- commercial use needs its own patent consideration.
// The noiseless-coding tables further down are generated from ISO/IEC 14496-3; the block below
// carries their notice.

#include "../../../../inc/c/format/audio/AAC.h"
#include "../../../../inc/c/ustring.h"
#include "../../../../inc/c/arith.h"

#if defined(_INC_CPP)

namespace {

	// Byte-wise read over a StorageTrait; the block interface below is not required to be
	// random-access at this granularity and every container helper does the same thing.
	static bool StorageReadExact(uni::StorageTrait& storage, uint64 offset, void* dst, size_t len) {
		if (len == 0) return true;
		byte* p = (byte*)dst;
		for (size_t i = 0; i < len; ++i) {
			int b = storage[offset + i];
			if (b < 0) return false;
			p[i] = (byte)b;
		}
		return true;
	}

// Phase: AAC-LC (Advanced Audio Coding Low Complexity) Core Decoder Engine
// ISO/IEC 14496-3 Part 3: Audio (MPEG-4 Audio)

// ---------------------------------------------------------------------------
// Noiseless-coding and codebook tables.
//
// Every table below is generated from ISO/IEC 14496-3, not copied from any other
// implementation:
//   Tables 4.A.1 .. 4.A.12  scalefactor and spectrum Huffman code books
//   Table 4.95              unsigned_cb / dim / LAV per code book
//   4.6.3.3                 codeword index -> n-tuple
//   Table 4.73              scalefactor band offsets, 48 kHz long window
// The generator scripts are named in the headers of each block.  Do not hand-edit.
// ---------------------------------------------------------------------------

#include <stdint.h>
#include <stddef.h>


// AAC noiseless-coding tables.
// Source: ISO/IEC 14496-3:2001 Annex 4.A, Tables 4.A.1 .. 4.A.12.
// Generated, not transcribed: see iso_gen_tables.py. Do not hand-edit.

static const uint32_t s_aac_scalefactor_code[121] = {
	0x3ffe8, 0x3ffe6, 0x3ffe7, 0x3ffe5, 0x7fff5, 0x7fff1, 0x7ffed, 0x7fff6,
	0x7ffee, 0x7ffef, 0x7fff0, 0x7fffc, 0x7fffd, 0x7ffff, 0x7fffe, 0x7fff7,
	0x7fff8, 0x7fffb, 0x7fff9, 0x3ffe4, 0x7fffa, 0x3ffe3, 0x1ffef, 0x1fff0,
	0x0fff5, 0x1ffee, 0x0fff2, 0x0fff3, 0x0fff4, 0x0fff1, 0x07ff6, 0x07ff7,
	0x03ff9, 0x03ff5, 0x03ff7, 0x03ff3, 0x03ff6, 0x03ff2, 0x01ff7, 0x01ff5,
	0x00ff9, 0x00ff7, 0x00ff6, 0x007f9, 0x00ff4, 0x007f8, 0x003f9, 0x003f7,
	0x003f5, 0x001f8, 0x001f7, 0x000fa, 0x000f8, 0x000f6, 0x00079, 0x0003a,
	0x00038, 0x0001a, 0x0000b, 0x00004, 0x00000, 0x0000a, 0x0000c, 0x0001b,
	0x00039, 0x0003b, 0x00078, 0x0007a, 0x000f7, 0x000f9, 0x001f6, 0x001f9,
	0x003f4, 0x003f6, 0x003f8, 0x007f5, 0x007f4, 0x007f6, 0x007f7, 0x00ff5,
	0x00ff8, 0x01ff4, 0x01ff6, 0x01ff8, 0x03ff8, 0x03ff4, 0x0fff0, 0x07ff4,
	0x0fff6, 0x07ff5, 0x3ffe2, 0x7ffd9, 0x7ffda, 0x7ffdb, 0x7ffdc, 0x7ffdd,
	0x7ffde, 0x7ffd8, 0x7ffd2, 0x7ffd3, 0x7ffd4, 0x7ffd5, 0x7ffd6, 0x7fff2,
	0x7ffdf, 0x7ffe7, 0x7ffe8, 0x7ffe9, 0x7ffea, 0x7ffeb, 0x7ffe6, 0x7ffe0,
	0x7ffe1, 0x7ffe2, 0x7ffe3, 0x7ffe4, 0x7ffe5, 0x7ffd7, 0x7ffec, 0x7fff4,
	0x7fff3,
};

static const uint8_t s_aac_scalefactor_bits[121] = {
	18, 18, 18, 18, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19,
	19, 19, 19, 18, 19, 18, 17, 17, 16, 17, 16, 16, 16, 16, 15, 15,
	14, 14, 14, 14, 14, 14, 13, 13, 12, 12, 12, 11, 12, 11, 10, 10,
	10, 9, 9, 8, 8, 8, 7, 6, 6, 5, 4, 3, 1, 4, 4, 5,
	6, 6, 7, 7, 8, 8, 9, 9, 10, 10, 10, 11, 11, 11, 11, 12,
	12, 13, 13, 13, 14, 14, 16, 15, 16, 15, 18, 19, 19, 19, 19, 19,
	19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19, 19,
	19, 19, 19, 19, 19, 19, 19, 19, 19,
};

static const uint16_t s_aac_spectral_codes_1[81] = {
	0x07f8, 0x01f1, 0x07fd, 0x03f5, 0x0068, 0x03f0, 0x07f7, 0x01ec, 0x07f5, 0x03f1, 0x0072, 0x03f4,
	0x0074, 0x0011, 0x0076, 0x01eb, 0x006c, 0x03f6, 0x07fc, 0x01e1, 0x07f1, 0x01f0, 0x0061, 0x01f6,
	0x07f2, 0x01ea, 0x07fb, 0x01f2, 0x0069, 0x01ed, 0x0077, 0x0017, 0x006f, 0x01e6, 0x0064, 0x01e5,
	0x0067, 0x0015, 0x0062, 0x0012, 0x0000, 0x0014, 0x0065, 0x0016, 0x006d, 0x01e9, 0x0063, 0x01e4,
	0x006b, 0x0013, 0x0071, 0x01e3, 0x0070, 0x01f3, 0x07fe, 0x01e7, 0x07f3, 0x01ef, 0x0060, 0x01ee,
	0x07f0, 0x01e2, 0x07fa, 0x03f3, 0x006a, 0x01e8, 0x0075, 0x0010, 0x0073, 0x01f4, 0x006e, 0x03f7,
	0x07f6, 0x01e0, 0x07f9, 0x03f2, 0x0066, 0x01f5, 0x07ff, 0x01f7, 0x07f4,
};

static const uint8_t s_aac_spectral_bits_1[81] = {
	11, 9, 11, 10, 7, 10, 11, 9, 11, 10, 7, 10, 7, 5, 7, 9,
	7, 10, 11, 9, 11, 9, 7, 9, 11, 9, 11, 9, 7, 9, 7, 5,
	7, 9, 7, 9, 7, 5, 7, 5, 1, 5, 7, 5, 7, 9, 7, 9,
	7, 5, 7, 9, 7, 9, 11, 9, 11, 9, 7, 9, 11, 9, 11, 10,
	7, 9, 7, 5, 7, 9, 7, 10, 11, 9, 11, 10, 7, 9, 11, 9,
	11,
};

static const uint16_t s_aac_spectral_codes_2[81] = {
	0x01f3, 0x006f, 0x01fd, 0x00eb, 0x0023, 0x00ea, 0x01f7, 0x00e8, 0x01fa, 0x00f2, 0x002d, 0x0070,
	0x0020, 0x0006, 0x002b, 0x006e, 0x0028, 0x00e9, 0x01f9, 0x0066, 0x00f8, 0x00e7, 0x001b, 0x00f1,
	0x01f4, 0x006b, 0x01f5, 0x00ec, 0x002a, 0x006c, 0x002c, 0x000a, 0x0027, 0x0067, 0x001a, 0x00f5,
	0x0024, 0x0008, 0x001f, 0x0009, 0x0000, 0x0007, 0x001d, 0x000b, 0x0030, 0x00ef, 0x001c, 0x0064,
	0x001e, 0x000c, 0x0029, 0x00f3, 0x002f, 0x00f0, 0x01fc, 0x0071, 0x01f2, 0x00f4, 0x0021, 0x00e6,
	0x00f7, 0x0068, 0x01f8, 0x00ee, 0x0022, 0x0065, 0x0031, 0x0002, 0x0026, 0x00ed, 0x0025, 0x006a,
	0x01fb, 0x0072, 0x01fe, 0x0069, 0x002e, 0x00f6, 0x01ff, 0x006d, 0x01f6,
};

static const uint8_t s_aac_spectral_bits_2[81] = {
	9, 7, 9, 8, 6, 8, 9, 8, 9, 8, 6, 7, 6, 5, 6, 7,
	6, 8, 9, 7, 8, 8, 6, 8, 9, 7, 9, 8, 6, 7, 6, 5,
	6, 7, 6, 8, 6, 5, 6, 5, 3, 5, 6, 5, 6, 8, 6, 7,
	6, 5, 6, 8, 6, 8, 9, 7, 9, 8, 6, 8, 8, 7, 9, 8,
	6, 7, 6, 4, 6, 8, 6, 7, 9, 7, 9, 7, 6, 8, 9, 7,
	9,
};

static const uint16_t s_aac_spectral_codes_3[81] = {
	0x0000, 0x0009, 0x00ef, 0x000b, 0x0019, 0x00f0, 0x01eb, 0x01e6, 0x03f2, 0x000a, 0x0035, 0x01ef,
	0x0034, 0x0037, 0x01e9, 0x01ed, 0x01e7, 0x03f3, 0x01ee, 0x03ed, 0x1ffa, 0x01ec, 0x01f2, 0x07f9,
	0x07f8, 0x03f8, 0x0ff8, 0x0008, 0x0038, 0x03f6, 0x0036, 0x0075, 0x03f1, 0x03eb, 0x03ec, 0x0ff4,
	0x0018, 0x0076, 0x07f4, 0x0039, 0x0074, 0x03ef, 0x01f3, 0x01f4, 0x07f6, 0x01e8, 0x03ea, 0x1ffc,
	0x00f2, 0x01f1, 0x0ffb, 0x03f5, 0x07f3, 0x0ffc, 0x00ee, 0x03f7, 0x7ffe, 0x01f0, 0x07f5, 0x7ffd,
	0x1ffb, 0x3ffa, 0xffff, 0x00f1, 0x03f0, 0x3ffc, 0x01ea, 0x03ee, 0x3ffb, 0x0ff6, 0x0ffa, 0x7ffc,
	0x07f2, 0x0ff5, 0xfffe, 0x03f4, 0x07f7, 0x7ffb, 0x0ff7, 0x0ff9, 0x7ffa,
};

static const uint8_t s_aac_spectral_bits_3[81] = {
	1, 4, 8, 4, 5, 8, 9, 9, 10, 4, 6, 9, 6, 6, 9, 9,
	9, 10, 9, 10, 13, 9, 9, 11, 11, 10, 12, 4, 6, 10, 6, 7,
	10, 10, 10, 12, 5, 7, 11, 6, 7, 10, 9, 9, 11, 9, 10, 13,
	8, 9, 12, 10, 11, 12, 8, 10, 15, 9, 11, 15, 13, 14, 16, 8,
	10, 14, 9, 10, 14, 12, 12, 15, 11, 12, 16, 10, 11, 15, 12, 12,
	15,
};

static const uint16_t s_aac_spectral_codes_4[81] = {
	0x0007, 0x0016, 0x00f6, 0x0018, 0x0008, 0x00ef, 0x01ef, 0x00f3, 0x07f8, 0x0019, 0x0017, 0x00ed,
	0x0015, 0x0001, 0x00e2, 0x00f0, 0x0070, 0x03f0, 0x01ee, 0x00f1, 0x07fa, 0x00ee, 0x00e4, 0x03f2,
	0x07f6, 0x03ef, 0x07fd, 0x0005, 0x0014, 0x00f2, 0x0009, 0x0004, 0x00e5, 0x00f4, 0x00e8, 0x03f4,
	0x0006, 0x0002, 0x00e7, 0x0003, 0x0000, 0x006b, 0x00e3, 0x0069, 0x01f3, 0x00eb, 0x00e6, 0x03f6,
	0x006e, 0x006a, 0x01f4, 0x03ec, 0x01f0, 0x03f9, 0x00f5, 0x00ec, 0x07fb, 0x00ea, 0x006f, 0x03f7,
	0x07f9, 0x03f3, 0x0fff, 0x00e9, 0x006d, 0x03f8, 0x006c, 0x0068, 0x01f5, 0x03ee, 0x01f2, 0x07f4,
	0x07f7, 0x03f1, 0x0ffe, 0x03ed, 0x01f1, 0x07f5, 0x07fe, 0x03f5, 0x07fc,
};

static const uint8_t s_aac_spectral_bits_4[81] = {
	4, 5, 8, 5, 4, 8, 9, 8, 11, 5, 5, 8, 5, 4, 8, 8,
	7, 10, 9, 8, 11, 8, 8, 10, 11, 10, 11, 4, 5, 8, 4, 4,
	8, 8, 8, 10, 4, 4, 8, 4, 4, 7, 8, 7, 9, 8, 8, 10,
	7, 7, 9, 10, 9, 10, 8, 8, 11, 8, 7, 10, 11, 10, 12, 8,
	7, 10, 7, 7, 9, 10, 9, 11, 11, 10, 12, 10, 9, 11, 11, 10,
	11,
};

static const uint16_t s_aac_spectral_codes_5[81] = {
	0x1fff, 0x0ff7, 0x07f4, 0x07e8, 0x03f1, 0x07ee, 0x07f9, 0x0ff8, 0x1ffd, 0x0ffd, 0x07f1, 0x03e8,
	0x01e8, 0x00f0, 0x01ec, 0x03ee, 0x07f2, 0x0ffa, 0x0ff4, 0x03ef, 0x01f2, 0x00e8, 0x0070, 0x00ec,
	0x01f0, 0x03ea, 0x07f3, 0x07eb, 0x01eb, 0x00ea, 0x001a, 0x0008, 0x0019, 0x00ee, 0x01ef, 0x07ed,
	0x03f0, 0x00f2, 0x0073, 0x000b, 0x0000, 0x000a, 0x0071, 0x00f3, 0x07e9, 0x07ef, 0x01ee, 0x00ef,
	0x0018, 0x0009, 0x001b, 0x00eb, 0x01e9, 0x07ec, 0x07f6, 0x03eb, 0x01f3, 0x00ed, 0x0072, 0x00e9,
	0x01f1, 0x03ed, 0x07f7, 0x0ff6, 0x07f0, 0x03e9, 0x01ed, 0x00f1, 0x01ea, 0x03ec, 0x07f8, 0x0ff9,
	0x1ffc, 0x0ffc, 0x0ff5, 0x07ea, 0x03f3, 0x03f2, 0x07f5, 0x0ffb, 0x1ffe,
};

static const uint8_t s_aac_spectral_bits_5[81] = {
	13, 12, 11, 11, 10, 11, 11, 12, 13, 12, 11, 10, 9, 8, 9, 10,
	11, 12, 12, 10, 9, 8, 7, 8, 9, 10, 11, 11, 9, 8, 5, 4,
	5, 8, 9, 11, 10, 8, 7, 4, 1, 4, 7, 8, 11, 11, 9, 8,
	5, 4, 5, 8, 9, 11, 11, 10, 9, 8, 7, 8, 9, 10, 11, 12,
	11, 10, 9, 8, 9, 10, 11, 12, 13, 12, 12, 11, 10, 10, 11, 12,
	13,
};

static const uint16_t s_aac_spectral_codes_6[81] = {
	0x07fe, 0x03fd, 0x01f1, 0x01eb, 0x01f4, 0x01ea, 0x01f0, 0x03fc, 0x07fd, 0x03f6, 0x01e5, 0x00ea,
	0x006c, 0x0071, 0x0068, 0x00f0, 0x01e6, 0x03f7, 0x01f3, 0x00ef, 0x0032, 0x0027, 0x0028, 0x0026,
	0x0031, 0x00eb, 0x01f7, 0x01e8, 0x006f, 0x002e, 0x0008, 0x0004, 0x0006, 0x0029, 0x006b, 0x01ee,
	0x01ef, 0x0072, 0x002d, 0x0002, 0x0000, 0x0003, 0x002f, 0x0073, 0x01fa, 0x01e7, 0x006e, 0x002b,
	0x0007, 0x0001, 0x0005, 0x002c, 0x006d, 0x01ec, 0x01f9, 0x00ee, 0x0030, 0x0024, 0x002a, 0x0025,
	0x0033, 0x00ec, 0x01f2, 0x03f8, 0x01e4, 0x00ed, 0x006a, 0x0070, 0x0069, 0x0074, 0x00f1, 0x03fa,
	0x07ff, 0x03f9, 0x01f6, 0x01ed, 0x01f8, 0x01e9, 0x01f5, 0x03fb, 0x07fc,
};

static const uint8_t s_aac_spectral_bits_6[81] = {
	11, 10, 9, 9, 9, 9, 9, 10, 11, 10, 9, 8, 7, 7, 7, 8,
	9, 10, 9, 8, 6, 6, 6, 6, 6, 8, 9, 9, 7, 6, 4, 4,
	4, 6, 7, 9, 9, 7, 6, 4, 4, 4, 6, 7, 9, 9, 7, 6,
	4, 4, 4, 6, 7, 9, 9, 8, 6, 6, 6, 6, 6, 8, 9, 10,
	9, 8, 7, 7, 7, 7, 8, 10, 11, 10, 9, 9, 9, 9, 9, 10,
	11,
};

static const uint16_t s_aac_spectral_codes_7[64] = {
	0x0000, 0x0005, 0x0037, 0x0074, 0x00f2, 0x01eb, 0x03ed, 0x07f7, 0x0004, 0x000c, 0x0035, 0x0071,
	0x00ec, 0x00ee, 0x01ee, 0x01f5, 0x0036, 0x0034, 0x0072, 0x00ea, 0x00f1, 0x01e9, 0x01f3, 0x03f5,
	0x0073, 0x0070, 0x00eb, 0x00f0, 0x01f1, 0x01f0, 0x03ec, 0x03fa, 0x00f3, 0x00ed, 0x01e8, 0x01ef,
	0x03ef, 0x03f1, 0x03f9, 0x07fb, 0x01ed, 0x00ef, 0x01ea, 0x01f2, 0x03f3, 0x03f8, 0x07f9, 0x07fc,
	0x03ee, 0x01ec, 0x01f4, 0x03f4, 0x03f7, 0x07f8, 0x0ffd, 0x0ffe, 0x07f6, 0x03f0, 0x03f2, 0x03f6,
	0x07fa, 0x07fd, 0x0ffc, 0x0fff,
};

static const uint8_t s_aac_spectral_bits_7[64] = {
	1, 3, 6, 7, 8, 9, 10, 11, 3, 4, 6, 7, 8, 8, 9, 9,
	6, 6, 7, 8, 8, 9, 9, 10, 7, 7, 8, 8, 9, 9, 10, 10,
	8, 8, 9, 9, 10, 10, 10, 11, 9, 8, 9, 9, 10, 10, 11, 11,
	10, 9, 9, 10, 10, 11, 12, 12, 11, 10, 10, 10, 11, 11, 12, 12,
};

static const uint16_t s_aac_spectral_codes_8[64] = {
	0x000e, 0x0005, 0x0010, 0x0030, 0x006f, 0x00f1, 0x01fa, 0x03fe, 0x0003, 0x0000, 0x0004, 0x0012,
	0x002c, 0x006a, 0x0075, 0x00f8, 0x000f, 0x0002, 0x0006, 0x0014, 0x002e, 0x0069, 0x0072, 0x00f5,
	0x002f, 0x0011, 0x0013, 0x002a, 0x0032, 0x006c, 0x00ec, 0x00fa, 0x0071, 0x002b, 0x002d, 0x0031,
	0x006d, 0x0070, 0x00f2, 0x01f9, 0x00ef, 0x0068, 0x0033, 0x006b, 0x006e, 0x00ee, 0x00f9, 0x03fc,
	0x01f8, 0x0074, 0x0073, 0x00ed, 0x00f0, 0x00f6, 0x01f6, 0x01fd, 0x03fd, 0x00f3, 0x00f4, 0x00f7,
	0x01f7, 0x01fb, 0x01fc, 0x03ff,
};

static const uint8_t s_aac_spectral_bits_8[64] = {
	5, 4, 5, 6, 7, 8, 9, 10, 4, 3, 4, 5, 6, 7, 7, 8,
	5, 4, 4, 5, 6, 7, 7, 8, 6, 5, 5, 6, 6, 7, 8, 8,
	7, 6, 6, 6, 7, 7, 8, 9, 8, 7, 6, 7, 7, 8, 8, 10,
	9, 7, 7, 8, 8, 8, 9, 9, 10, 8, 8, 8, 9, 9, 9, 10,
};

static const uint16_t s_aac_spectral_codes_9[169] = {
	0x0000, 0x0005, 0x0037, 0x00e7, 0x01de, 0x03ce, 0x03d9, 0x07c8, 0x07cd, 0x0fc8, 0x0fdd, 0x1fe4,
	0x1fec, 0x0004, 0x000c, 0x0035, 0x0072, 0x00ea, 0x00ed, 0x01e2, 0x03d1, 0x03d3, 0x03e0, 0x07d8,
	0x0fcf, 0x0fd5, 0x0036, 0x0034, 0x0071, 0x00e8, 0x00ec, 0x01e1, 0x03cf, 0x03dd, 0x03db, 0x07d0,
	0x0fc7, 0x0fd4, 0x0fe4, 0x00e6, 0x0070, 0x00e9, 0x01dd, 0x01e3, 0x03d2, 0x03dc, 0x07cc, 0x07ca,
	0x07de, 0x0fd8, 0x0fea, 0x1fdb, 0x01df, 0x00eb, 0x01dc, 0x01e6, 0x03d5, 0x03de, 0x07cb, 0x07dd,
	0x07dc, 0x0fcd, 0x0fe2, 0x0fe7, 0x1fe1, 0x03d0, 0x01e0, 0x01e4, 0x03d6, 0x07c5, 0x07d1, 0x07db,
	0x0fd2, 0x07e0, 0x0fd9, 0x0feb, 0x1fe3, 0x1fe9, 0x07c4, 0x01e5, 0x03d7, 0x07c6, 0x07cf, 0x07da,
	0x0fcb, 0x0fda, 0x0fe3, 0x0fe9, 0x1fe6, 0x1ff3, 0x1ff7, 0x07d3, 0x03d8, 0x03e1, 0x07d4, 0x07d9,
	0x0fd3, 0x0fde, 0x1fdd, 0x1fd9, 0x1fe2, 0x1fea, 0x1ff1, 0x1ff6, 0x07d2, 0x03d4, 0x03da, 0x07c7,
	0x07d7, 0x07e2, 0x0fce, 0x0fdb, 0x1fd8, 0x1fee, 0x3ff0, 0x1ff4, 0x3ff2, 0x07e1, 0x03df, 0x07c9,
	0x07d6, 0x0fca, 0x0fd0, 0x0fe5, 0x0fe6, 0x1feb, 0x1fef, 0x3ff3, 0x3ff4, 0x3ff5, 0x0fe0, 0x07ce,
	0x07d5, 0x0fc6, 0x0fd1, 0x0fe1, 0x1fe0, 0x1fe8, 0x1ff0, 0x3ff1, 0x3ff8, 0x3ff6, 0x7ffc, 0x0fe8,
	0x07df, 0x0fc9, 0x0fd7, 0x0fdc, 0x1fdc, 0x1fdf, 0x1fed, 0x1ff5, 0x3ff9, 0x3ffb, 0x7ffd, 0x7ffe,
	0x1fe7, 0x0fcc, 0x0fd6, 0x0fdf, 0x1fde, 0x1fda, 0x1fe5, 0x1ff2, 0x3ffa, 0x3ff7, 0x3ffc, 0x3ffd,
	0x7fff,
};

static const uint8_t s_aac_spectral_bits_9[169] = {
	1, 3, 6, 8, 9, 10, 10, 11, 11, 12, 12, 13, 13, 3, 4, 6,
	7, 8, 8, 9, 10, 10, 10, 11, 12, 12, 6, 6, 7, 8, 8, 9,
	10, 10, 10, 11, 12, 12, 12, 8, 7, 8, 9, 9, 10, 10, 11, 11,
	11, 12, 12, 13, 9, 8, 9, 9, 10, 10, 11, 11, 11, 12, 12, 12,
	13, 10, 9, 9, 10, 11, 11, 11, 12, 11, 12, 12, 13, 13, 11, 9,
	10, 11, 11, 11, 12, 12, 12, 12, 13, 13, 13, 11, 10, 10, 11, 11,
	12, 12, 13, 13, 13, 13, 13, 13, 11, 10, 10, 11, 11, 11, 12, 12,
	13, 13, 14, 13, 14, 11, 10, 11, 11, 12, 12, 12, 12, 13, 13, 14,
	14, 14, 12, 11, 11, 12, 12, 12, 13, 13, 13, 14, 14, 14, 15, 12,
	11, 12, 12, 12, 13, 13, 13, 13, 14, 14, 15, 15, 13, 12, 12, 12,
	13, 13, 13, 13, 14, 14, 14, 14, 15,
};

static const uint16_t s_aac_spectral_codes_10[169] = {
	0x0022, 0x0008, 0x001d, 0x0026, 0x005f, 0x00d3, 0x01cf, 0x03d0, 0x03d7, 0x03ed, 0x07f0, 0x07f6,
	0x0ffd, 0x0007, 0x0000, 0x0001, 0x0009, 0x0020, 0x0054, 0x0060, 0x00d5, 0x00dc, 0x01d4, 0x03cd,
	0x03de, 0x07e7, 0x001c, 0x0002, 0x0006, 0x000c, 0x001e, 0x0028, 0x005b, 0x00cd, 0x00d9, 0x01ce,
	0x01dc, 0x03d9, 0x03f1, 0x0025, 0x000b, 0x000a, 0x000d, 0x0024, 0x0057, 0x0061, 0x00cc, 0x00dd,
	0x01cc, 0x01de, 0x03d3, 0x03e7, 0x005d, 0x0021, 0x001f, 0x0023, 0x0027, 0x0059, 0x0064, 0x00d8,
	0x00df, 0x01d2, 0x01e2, 0x03dd, 0x03ee, 0x00d1, 0x0055, 0x0029, 0x0056, 0x0058, 0x0062, 0x00ce,
	0x00e0, 0x00e2, 0x01da, 0x03d4, 0x03e3, 0x07eb, 0x01c9, 0x005e, 0x005a, 0x005c, 0x0063, 0x00ca,
	0x00da, 0x01c7, 0x01ca, 0x01e0, 0x03db, 0x03e8, 0x07ec, 0x01e3, 0x00d2, 0x00cb, 0x00d0, 0x00d7,
	0x00db, 0x01c6, 0x01d5, 0x01d8, 0x03ca, 0x03da, 0x07ea, 0x07f1, 0x01e1, 0x00d4, 0x00cf, 0x00d6,
	0x00de, 0x00e1, 0x01d0, 0x01d6, 0x03d1, 0x03d5, 0x03f2, 0x07ee, 0x07fb, 0x03e9, 0x01cd, 0x01c8,
	0x01cb, 0x01d1, 0x01d7, 0x01df, 0x03cf, 0x03e0, 0x03ef, 0x07e6, 0x07f8, 0x0ffa, 0x03eb, 0x01dd,
	0x01d3, 0x01d9, 0x01db, 0x03d2, 0x03cc, 0x03dc, 0x03ea, 0x07ed, 0x07f3, 0x07f9, 0x0ff9, 0x07f2,
	0x03ce, 0x01e4, 0x03cb, 0x03d8, 0x03d6, 0x03e2, 0x03e5, 0x07e8, 0x07f4, 0x07f5, 0x07f7, 0x0ffb,
	0x07fa, 0x03ec, 0x03df, 0x03e1, 0x03e4, 0x03e6, 0x03f0, 0x07e9, 0x07ef, 0x0ff8, 0x0ffe, 0x0ffc,
	0x0fff,
};

static const uint8_t s_aac_spectral_bits_10[169] = {
	6, 5, 6, 6, 7, 8, 9, 10, 10, 10, 11, 11, 12, 5, 4, 4,
	5, 6, 7, 7, 8, 8, 9, 10, 10, 11, 6, 4, 5, 5, 6, 6,
	7, 8, 8, 9, 9, 10, 10, 6, 5, 5, 5, 6, 7, 7, 8, 8,
	9, 9, 10, 10, 7, 6, 6, 6, 6, 7, 7, 8, 8, 9, 9, 10,
	10, 8, 7, 6, 7, 7, 7, 8, 8, 8, 9, 10, 10, 11, 9, 7,
	7, 7, 7, 8, 8, 9, 9, 9, 10, 10, 11, 9, 8, 8, 8, 8,
	8, 9, 9, 9, 10, 10, 11, 11, 9, 8, 8, 8, 8, 8, 9, 9,
	10, 10, 10, 11, 11, 10, 9, 9, 9, 9, 9, 9, 10, 10, 10, 11,
	11, 12, 10, 9, 9, 9, 9, 10, 10, 10, 10, 11, 11, 11, 12, 11,
	10, 9, 10, 10, 10, 10, 10, 11, 11, 11, 11, 12, 11, 10, 10, 10,
	10, 10, 10, 11, 11, 12, 12, 12, 12,
};

static const uint16_t s_aac_spectral_codes_11[289] = {
	0x0000, 0x0006, 0x0019, 0x003d, 0x009c, 0x00c6, 0x01a7, 0x0390, 0x03c2, 0x03df, 0x07e6, 0x07f3,
	0x0ffb, 0x07ec, 0x0ffa, 0x0ffe, 0x038e, 0x0005, 0x0001, 0x0008, 0x0014, 0x0037, 0x0042, 0x0092,
	0x00af, 0x0191, 0x01a5, 0x01b5, 0x039e, 0x03c0, 0x03a2, 0x03cd, 0x07d6, 0x00ae, 0x0017, 0x0007,
	0x0009, 0x0018, 0x0039, 0x0040, 0x008e, 0x00a3, 0x00b8, 0x0199, 0x01ac, 0x01c1, 0x03b1, 0x0396,
	0x03be, 0x03ca, 0x009d, 0x003c, 0x0015, 0x0016, 0x001a, 0x003b, 0x0044, 0x0091, 0x00a5, 0x00be,
	0x0196, 0x01ae, 0x01b9, 0x03a1, 0x0391, 0x03a5, 0x03d5, 0x0094, 0x009a, 0x0036, 0x0038, 0x003a,
	0x0041, 0x008c, 0x009b, 0x00b0, 0x00c3, 0x019e, 0x01ab, 0x01bc, 0x039f, 0x038f, 0x03a9, 0x03cf,
	0x0093, 0x00bf, 0x003e, 0x003f, 0x0043, 0x0045, 0x009e, 0x00a7, 0x00b9, 0x0194, 0x01a2, 0x01ba,
	0x01c3, 0x03a6, 0x03a7, 0x03bb, 0x03d4, 0x009f, 0x01a0, 0x008f, 0x008d, 0x0090, 0x0098, 0x00a6,
	0x00b6, 0x00c4, 0x019f, 0x01af, 0x01bf, 0x0399, 0x03bf, 0x03b4, 0x03c9, 0x03e7, 0x00a8, 0x01b6,
	0x00ab, 0x00a4, 0x00aa, 0x00b2, 0x00c2, 0x00c5, 0x0198, 0x01a4, 0x01b8, 0x038c, 0x03a4, 0x03c4,
	0x03c6, 0x03dd, 0x03e8, 0x00ad, 0x03af, 0x0192, 0x00bd, 0x00bc, 0x018e, 0x0197, 0x019a, 0x01a3,
	0x01b1, 0x038d, 0x0398, 0x03b7, 0x03d3, 0x03d1, 0x03db, 0x07dd, 0x00b4, 0x03de, 0x01a9, 0x019b,
	0x019c, 0x01a1, 0x01aa, 0x01ad, 0x01b3, 0x038b, 0x03b2, 0x03b8, 0x03ce, 0x03e1, 0x03e0, 0x07d2,
	0x07e5, 0x00b7, 0x07e3, 0x01bb, 0x01a8, 0x01a6, 0x01b0, 0x01b2, 0x01b7, 0x039b, 0x039a, 0x03ba,
	0x03b5, 0x03d6, 0x07d7, 0x03e4, 0x07d8, 0x07ea, 0x00ba, 0x07e8, 0x03a0, 0x01bd, 0x01b4, 0x038a,
	0x01c4, 0x0392, 0x03aa, 0x03b0, 0x03bc, 0x03d7, 0x07d4, 0x07dc, 0x07db, 0x07d5, 0x07f0, 0x00c1,
	0x07fb, 0x03c8, 0x03a3, 0x0395, 0x039d, 0x03ac, 0x03ae, 0x03c5, 0x03d8, 0x03e2, 0x03e6, 0x07e4,
	0x07e7, 0x07e0, 0x07e9, 0x07f7, 0x0190, 0x07f2, 0x0393, 0x01be, 0x01c0, 0x0394, 0x0397, 0x03ad,
	0x03c3, 0x03c1, 0x03d2, 0x07da, 0x07d9, 0x07df, 0x07eb, 0x07f4, 0x07fa, 0x0195, 0x07f8, 0x03bd,
	0x039c, 0x03ab, 0x03a8, 0x03b3, 0x03b9, 0x03d0, 0x03e3, 0x03e5, 0x07e2, 0x07de, 0x07ed, 0x07f1,
	0x07f9, 0x07fc, 0x0193, 0x0ffd, 0x03dc, 0x03b6, 0x03c7, 0x03cc, 0x03cb, 0x03d9, 0x03da, 0x07d3,
	0x07e1, 0x07ee, 0x07ef, 0x07f5, 0x07f6, 0x0ffc, 0x0fff, 0x019d, 0x01c2, 0x00b5, 0x00a1, 0x0096,
	0x0097, 0x0095, 0x0099, 0x00a0, 0x00a2, 0x00ac, 0x00a9, 0x00b1, 0x00b3, 0x00bb, 0x00c0, 0x018f,
	0x0004,
};

static const uint8_t s_aac_spectral_bits_11[289] = {
	4, 5, 6, 7, 8, 8, 9, 10, 10, 10, 11, 11, 12, 11, 12, 12,
	10, 5, 4, 5, 6, 7, 7, 8, 8, 9, 9, 9, 10, 10, 10, 10,
	11, 8, 6, 5, 5, 6, 7, 7, 8, 8, 8, 9, 9, 9, 10, 10,
	10, 10, 8, 7, 6, 6, 6, 7, 7, 8, 8, 8, 9, 9, 9, 10,
	10, 10, 10, 8, 8, 7, 7, 7, 7, 8, 8, 8, 8, 9, 9, 9,
	10, 10, 10, 10, 8, 8, 7, 7, 7, 7, 8, 8, 8, 9, 9, 9,
	9, 10, 10, 10, 10, 8, 9, 8, 8, 8, 8, 8, 8, 8, 9, 9,
	9, 10, 10, 10, 10, 10, 8, 9, 8, 8, 8, 8, 8, 8, 9, 9,
	9, 10, 10, 10, 10, 10, 10, 8, 10, 9, 8, 8, 9, 9, 9, 9,
	9, 10, 10, 10, 10, 10, 10, 11, 8, 10, 9, 9, 9, 9, 9, 9,
	9, 10, 10, 10, 10, 10, 10, 11, 11, 8, 11, 9, 9, 9, 9, 9,
	9, 10, 10, 10, 10, 10, 11, 10, 11, 11, 8, 11, 10, 9, 9, 10,
	9, 10, 10, 10, 10, 10, 11, 11, 11, 11, 11, 8, 11, 10, 10, 10,
	10, 10, 10, 10, 10, 10, 10, 11, 11, 11, 11, 11, 9, 11, 10, 9,
	9, 10, 10, 10, 10, 10, 10, 11, 11, 11, 11, 11, 11, 9, 11, 10,
	10, 10, 10, 10, 10, 10, 10, 10, 11, 11, 11, 11, 11, 11, 9, 12,
	10, 10, 10, 10, 10, 10, 10, 11, 11, 11, 11, 11, 11, 12, 12, 9,
	9, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8, 8, 9,
	5,
};

// AAC codebook vector tables.
// Source: ISO/IEC 14496-3 subclause 4.6.3.3 (codeword index -> n-tuple) with the
// (unsigned_cb, dim, LAV) parameters of Table 4.95.  Generated by iso_gen_vectors.py.

static const float s_aac_codebook_vector_0[324] = {
	-1.0000000f, -1.0000000f, -1.0000000f, -1.0000000f, -1.0000000f, -1.0000000f, -1.0000000f, 0.0000000f,
	-1.0000000f, -1.0000000f, -1.0000000f, 1.0000000f, -1.0000000f, -1.0000000f, 0.0000000f, -1.0000000f,
	-1.0000000f, -1.0000000f, 0.0000000f, 0.0000000f, -1.0000000f, -1.0000000f, 0.0000000f, 1.0000000f,
	-1.0000000f, -1.0000000f, 1.0000000f, -1.0000000f, -1.0000000f, -1.0000000f, 1.0000000f, 0.0000000f,
	-1.0000000f, -1.0000000f, 1.0000000f, 1.0000000f, -1.0000000f, 0.0000000f, -1.0000000f, -1.0000000f,
	-1.0000000f, 0.0000000f, -1.0000000f, 0.0000000f, -1.0000000f, 0.0000000f, -1.0000000f, 1.0000000f,
	-1.0000000f, 0.0000000f, 0.0000000f, -1.0000000f, -1.0000000f, 0.0000000f, 0.0000000f, 0.0000000f,
	-1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, -1.0000000f, 0.0000000f, 1.0000000f, -1.0000000f,
	-1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, -1.0000000f, 0.0000000f, 1.0000000f, 1.0000000f,
	-1.0000000f, 1.0000000f, -1.0000000f, -1.0000000f, -1.0000000f, 1.0000000f, -1.0000000f, 0.0000000f,
	-1.0000000f, 1.0000000f, -1.0000000f, 1.0000000f, -1.0000000f, 1.0000000f, 0.0000000f, -1.0000000f,
	-1.0000000f, 1.0000000f, 0.0000000f, 0.0000000f, -1.0000000f, 1.0000000f, 0.0000000f, 1.0000000f,
	-1.0000000f, 1.0000000f, 1.0000000f, -1.0000000f, -1.0000000f, 1.0000000f, 1.0000000f, 0.0000000f,
	-1.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, -1.0000000f, -1.0000000f, -1.0000000f,
	0.0000000f, -1.0000000f, -1.0000000f, 0.0000000f, 0.0000000f, -1.0000000f, -1.0000000f, 1.0000000f,
	0.0000000f, -1.0000000f, 0.0000000f, -1.0000000f, 0.0000000f, -1.0000000f, 0.0000000f, 0.0000000f,
	0.0000000f, -1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, -1.0000000f, 1.0000000f, -1.0000000f,
	0.0000000f, -1.0000000f, 1.0000000f, 0.0000000f, 0.0000000f, -1.0000000f, 1.0000000f, 1.0000000f,
	0.0000000f, 0.0000000f, -1.0000000f, -1.0000000f, 0.0000000f, 0.0000000f, -1.0000000f, 0.0000000f,
	0.0000000f, 0.0000000f, -1.0000000f, 1.0000000f, 0.0000000f, 0.0000000f, 0.0000000f, -1.0000000f,
	0.0000000f, 0.0000000f, 0.0000000f, 0.0000000f, 0.0000000f, 0.0000000f, 0.0000000f, 1.0000000f,
	0.0000000f, 0.0000000f, 1.0000000f, -1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 0.0000000f,
	0.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, -1.0000000f, -1.0000000f,
	0.0000000f, 1.0000000f, -1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, -1.0000000f, 1.0000000f,
	0.0000000f, 1.0000000f, 0.0000000f, -1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 0.0000000f,
	0.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, -1.0000000f,
	0.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 1.0000000f,
	1.0000000f, -1.0000000f, -1.0000000f, -1.0000000f, 1.0000000f, -1.0000000f, -1.0000000f, 0.0000000f,
	1.0000000f, -1.0000000f, -1.0000000f, 1.0000000f, 1.0000000f, -1.0000000f, 0.0000000f, -1.0000000f,
	1.0000000f, -1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, -1.0000000f, 0.0000000f, 1.0000000f,
	1.0000000f, -1.0000000f, 1.0000000f, -1.0000000f, 1.0000000f, -1.0000000f, 1.0000000f, 0.0000000f,
	1.0000000f, -1.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, -1.0000000f, -1.0000000f,
	1.0000000f, 0.0000000f, -1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, -1.0000000f, 1.0000000f,
	1.0000000f, 0.0000000f, 0.0000000f, -1.0000000f, 1.0000000f, 0.0000000f, 0.0000000f, 0.0000000f,
	1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, -1.0000000f,
	1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, 1.0000000f,
	1.0000000f, 1.0000000f, -1.0000000f, -1.0000000f, 1.0000000f, 1.0000000f, -1.0000000f, 0.0000000f,
	1.0000000f, 1.0000000f, -1.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, -1.0000000f,
	1.0000000f, 1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, 1.0000000f,
	1.0000000f, 1.0000000f, 1.0000000f, -1.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 0.0000000f,
	1.0000000f, 1.0000000f, 1.0000000f, 1.0000000f,
};

static const float s_aac_codebook_vector_2[324] = {
	0.0000000f, 0.0000000f, 0.0000000f, 0.0000000f, 0.0000000f, 0.0000000f, 0.0000000f, 1.0000000f,
	0.0000000f, 0.0000000f, 0.0000000f, 2.5198421f, 0.0000000f, 0.0000000f, 1.0000000f, 0.0000000f,
	0.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 2.5198421f,
	0.0000000f, 0.0000000f, 2.5198421f, 0.0000000f, 0.0000000f, 0.0000000f, 2.5198421f, 1.0000000f,
	0.0000000f, 0.0000000f, 2.5198421f, 2.5198421f, 0.0000000f, 1.0000000f, 0.0000000f, 0.0000000f,
	0.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 2.5198421f,
	0.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 1.0000000f,
	0.0000000f, 1.0000000f, 1.0000000f, 2.5198421f, 0.0000000f, 1.0000000f, 2.5198421f, 0.0000000f,
	0.0000000f, 1.0000000f, 2.5198421f, 1.0000000f, 0.0000000f, 1.0000000f, 2.5198421f, 2.5198421f,
	0.0000000f, 2.5198421f, 0.0000000f, 0.0000000f, 0.0000000f, 2.5198421f, 0.0000000f, 1.0000000f,
	0.0000000f, 2.5198421f, 0.0000000f, 2.5198421f, 0.0000000f, 2.5198421f, 1.0000000f, 0.0000000f,
	0.0000000f, 2.5198421f, 1.0000000f, 1.0000000f, 0.0000000f, 2.5198421f, 1.0000000f, 2.5198421f,
	0.0000000f, 2.5198421f, 2.5198421f, 0.0000000f, 0.0000000f, 2.5198421f, 2.5198421f, 1.0000000f,
	0.0000000f, 2.5198421f, 2.5198421f, 2.5198421f, 1.0000000f, 0.0000000f, 0.0000000f, 0.0000000f,
	1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, 0.0000000f, 2.5198421f,
	1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, 1.0000000f,
	1.0000000f, 0.0000000f, 1.0000000f, 2.5198421f, 1.0000000f, 0.0000000f, 2.5198421f, 0.0000000f,
	1.0000000f, 0.0000000f, 2.5198421f, 1.0000000f, 1.0000000f, 0.0000000f, 2.5198421f, 2.5198421f,
	1.0000000f, 1.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 0.0000000f, 1.0000000f,
	1.0000000f, 1.0000000f, 0.0000000f, 2.5198421f, 1.0000000f, 1.0000000f, 1.0000000f, 0.0000000f,
	1.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 2.5198421f,
	1.0000000f, 1.0000000f, 2.5198421f, 0.0000000f, 1.0000000f, 1.0000000f, 2.5198421f, 1.0000000f,
	1.0000000f, 1.0000000f, 2.5198421f, 2.5198421f, 1.0000000f, 2.5198421f, 0.0000000f, 0.0000000f,
	1.0000000f, 2.5198421f, 0.0000000f, 1.0000000f, 1.0000000f, 2.5198421f, 0.0000000f, 2.5198421f,
	1.0000000f, 2.5198421f, 1.0000000f, 0.0000000f, 1.0000000f, 2.5198421f, 1.0000000f, 1.0000000f,
	1.0000000f, 2.5198421f, 1.0000000f, 2.5198421f, 1.0000000f, 2.5198421f, 2.5198421f, 0.0000000f,
	1.0000000f, 2.5198421f, 2.5198421f, 1.0000000f, 1.0000000f, 2.5198421f, 2.5198421f, 2.5198421f,
	2.5198421f, 0.0000000f, 0.0000000f, 0.0000000f, 2.5198421f, 0.0000000f, 0.0000000f, 1.0000000f,
	2.5198421f, 0.0000000f, 0.0000000f, 2.5198421f, 2.5198421f, 0.0000000f, 1.0000000f, 0.0000000f,
	2.5198421f, 0.0000000f, 1.0000000f, 1.0000000f, 2.5198421f, 0.0000000f, 1.0000000f, 2.5198421f,
	2.5198421f, 0.0000000f, 2.5198421f, 0.0000000f, 2.5198421f, 0.0000000f, 2.5198421f, 1.0000000f,
	2.5198421f, 0.0000000f, 2.5198421f, 2.5198421f, 2.5198421f, 1.0000000f, 0.0000000f, 0.0000000f,
	2.5198421f, 1.0000000f, 0.0000000f, 1.0000000f, 2.5198421f, 1.0000000f, 0.0000000f, 2.5198421f,
	2.5198421f, 1.0000000f, 1.0000000f, 0.0000000f, 2.5198421f, 1.0000000f, 1.0000000f, 1.0000000f,
	2.5198421f, 1.0000000f, 1.0000000f, 2.5198421f, 2.5198421f, 1.0000000f, 2.5198421f, 0.0000000f,
	2.5198421f, 1.0000000f, 2.5198421f, 1.0000000f, 2.5198421f, 1.0000000f, 2.5198421f, 2.5198421f,
	2.5198421f, 2.5198421f, 0.0000000f, 0.0000000f, 2.5198421f, 2.5198421f, 0.0000000f, 1.0000000f,
	2.5198421f, 2.5198421f, 0.0000000f, 2.5198421f, 2.5198421f, 2.5198421f, 1.0000000f, 0.0000000f,
	2.5198421f, 2.5198421f, 1.0000000f, 1.0000000f, 2.5198421f, 2.5198421f, 1.0000000f, 2.5198421f,
	2.5198421f, 2.5198421f, 2.5198421f, 0.0000000f, 2.5198421f, 2.5198421f, 2.5198421f, 1.0000000f,
	2.5198421f, 2.5198421f, 2.5198421f, 2.5198421f,
};

static const float s_aac_codebook_vector_4[162] = {
	-6.3496042f, -6.3496042f, -6.3496042f, -4.3267487f, -6.3496042f, -2.5198421f, -6.3496042f, -1.0000000f,
	-6.3496042f, 0.0000000f, -6.3496042f, 1.0000000f, -6.3496042f, 2.5198421f, -6.3496042f, 4.3267487f,
	-6.3496042f, 6.3496042f, -4.3267487f, -6.3496042f, -4.3267487f, -4.3267487f, -4.3267487f, -2.5198421f,
	-4.3267487f, -1.0000000f, -4.3267487f, 0.0000000f, -4.3267487f, 1.0000000f, -4.3267487f, 2.5198421f,
	-4.3267487f, 4.3267487f, -4.3267487f, 6.3496042f, -2.5198421f, -6.3496042f, -2.5198421f, -4.3267487f,
	-2.5198421f, -2.5198421f, -2.5198421f, -1.0000000f, -2.5198421f, 0.0000000f, -2.5198421f, 1.0000000f,
	-2.5198421f, 2.5198421f, -2.5198421f, 4.3267487f, -2.5198421f, 6.3496042f, -1.0000000f, -6.3496042f,
	-1.0000000f, -4.3267487f, -1.0000000f, -2.5198421f, -1.0000000f, -1.0000000f, -1.0000000f, 0.0000000f,
	-1.0000000f, 1.0000000f, -1.0000000f, 2.5198421f, -1.0000000f, 4.3267487f, -1.0000000f, 6.3496042f,
	0.0000000f, -6.3496042f, 0.0000000f, -4.3267487f, 0.0000000f, -2.5198421f, 0.0000000f, -1.0000000f,
	0.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 2.5198421f, 0.0000000f, 4.3267487f,
	0.0000000f, 6.3496042f, 1.0000000f, -6.3496042f, 1.0000000f, -4.3267487f, 1.0000000f, -2.5198421f,
	1.0000000f, -1.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 2.5198421f,
	1.0000000f, 4.3267487f, 1.0000000f, 6.3496042f, 2.5198421f, -6.3496042f, 2.5198421f, -4.3267487f,
	2.5198421f, -2.5198421f, 2.5198421f, -1.0000000f, 2.5198421f, 0.0000000f, 2.5198421f, 1.0000000f,
	2.5198421f, 2.5198421f, 2.5198421f, 4.3267487f, 2.5198421f, 6.3496042f, 4.3267487f, -6.3496042f,
	4.3267487f, -4.3267487f, 4.3267487f, -2.5198421f, 4.3267487f, -1.0000000f, 4.3267487f, 0.0000000f,
	4.3267487f, 1.0000000f, 4.3267487f, 2.5198421f, 4.3267487f, 4.3267487f, 4.3267487f, 6.3496042f,
	6.3496042f, -6.3496042f, 6.3496042f, -4.3267487f, 6.3496042f, -2.5198421f, 6.3496042f, -1.0000000f,
	6.3496042f, 0.0000000f, 6.3496042f, 1.0000000f, 6.3496042f, 2.5198421f, 6.3496042f, 4.3267487f,
	6.3496042f, 6.3496042f,
};

static const float s_aac_codebook_vector_6[128] = {
	0.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 2.5198421f, 0.0000000f, 4.3267487f,
	0.0000000f, 6.3496042f, 0.0000000f, 8.5498797f, 0.0000000f, 10.9027236f, 0.0000000f, 13.3905183f,
	1.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 2.5198421f, 1.0000000f, 4.3267487f,
	1.0000000f, 6.3496042f, 1.0000000f, 8.5498797f, 1.0000000f, 10.9027236f, 1.0000000f, 13.3905183f,
	2.5198421f, 0.0000000f, 2.5198421f, 1.0000000f, 2.5198421f, 2.5198421f, 2.5198421f, 4.3267487f,
	2.5198421f, 6.3496042f, 2.5198421f, 8.5498797f, 2.5198421f, 10.9027236f, 2.5198421f, 13.3905183f,
	4.3267487f, 0.0000000f, 4.3267487f, 1.0000000f, 4.3267487f, 2.5198421f, 4.3267487f, 4.3267487f,
	4.3267487f, 6.3496042f, 4.3267487f, 8.5498797f, 4.3267487f, 10.9027236f, 4.3267487f, 13.3905183f,
	6.3496042f, 0.0000000f, 6.3496042f, 1.0000000f, 6.3496042f, 2.5198421f, 6.3496042f, 4.3267487f,
	6.3496042f, 6.3496042f, 6.3496042f, 8.5498797f, 6.3496042f, 10.9027236f, 6.3496042f, 13.3905183f,
	8.5498797f, 0.0000000f, 8.5498797f, 1.0000000f, 8.5498797f, 2.5198421f, 8.5498797f, 4.3267487f,
	8.5498797f, 6.3496042f, 8.5498797f, 8.5498797f, 8.5498797f, 10.9027236f, 8.5498797f, 13.3905183f,
	10.9027236f, 0.0000000f, 10.9027236f, 1.0000000f, 10.9027236f, 2.5198421f, 10.9027236f, 4.3267487f,
	10.9027236f, 6.3496042f, 10.9027236f, 8.5498797f, 10.9027236f, 10.9027236f, 10.9027236f, 13.3905183f,
	13.3905183f, 0.0000000f, 13.3905183f, 1.0000000f, 13.3905183f, 2.5198421f, 13.3905183f, 4.3267487f,
	13.3905183f, 6.3496042f, 13.3905183f, 8.5498797f, 13.3905183f, 10.9027236f, 13.3905183f, 13.3905183f,
};

static const float s_aac_codebook_vector_8[338] = {
	0.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 2.5198421f, 0.0000000f, 4.3267487f,
	0.0000000f, 6.3496042f, 0.0000000f, 8.5498797f, 0.0000000f, 10.9027236f, 0.0000000f, 13.3905183f,
	0.0000000f, 16.0000000f, 0.0000000f, 18.7207544f, 0.0000000f, 21.5443469f, 0.0000000f, 24.4637810f,
	0.0000000f, 27.4731418f, 1.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 2.5198421f,
	1.0000000f, 4.3267487f, 1.0000000f, 6.3496042f, 1.0000000f, 8.5498797f, 1.0000000f, 10.9027236f,
	1.0000000f, 13.3905183f, 1.0000000f, 16.0000000f, 1.0000000f, 18.7207544f, 1.0000000f, 21.5443469f,
	1.0000000f, 24.4637810f, 1.0000000f, 27.4731418f, 2.5198421f, 0.0000000f, 2.5198421f, 1.0000000f,
	2.5198421f, 2.5198421f, 2.5198421f, 4.3267487f, 2.5198421f, 6.3496042f, 2.5198421f, 8.5498797f,
	2.5198421f, 10.9027236f, 2.5198421f, 13.3905183f, 2.5198421f, 16.0000000f, 2.5198421f, 18.7207544f,
	2.5198421f, 21.5443469f, 2.5198421f, 24.4637810f, 2.5198421f, 27.4731418f, 4.3267487f, 0.0000000f,
	4.3267487f, 1.0000000f, 4.3267487f, 2.5198421f, 4.3267487f, 4.3267487f, 4.3267487f, 6.3496042f,
	4.3267487f, 8.5498797f, 4.3267487f, 10.9027236f, 4.3267487f, 13.3905183f, 4.3267487f, 16.0000000f,
	4.3267487f, 18.7207544f, 4.3267487f, 21.5443469f, 4.3267487f, 24.4637810f, 4.3267487f, 27.4731418f,
	6.3496042f, 0.0000000f, 6.3496042f, 1.0000000f, 6.3496042f, 2.5198421f, 6.3496042f, 4.3267487f,
	6.3496042f, 6.3496042f, 6.3496042f, 8.5498797f, 6.3496042f, 10.9027236f, 6.3496042f, 13.3905183f,
	6.3496042f, 16.0000000f, 6.3496042f, 18.7207544f, 6.3496042f, 21.5443469f, 6.3496042f, 24.4637810f,
	6.3496042f, 27.4731418f, 8.5498797f, 0.0000000f, 8.5498797f, 1.0000000f, 8.5498797f, 2.5198421f,
	8.5498797f, 4.3267487f, 8.5498797f, 6.3496042f, 8.5498797f, 8.5498797f, 8.5498797f, 10.9027236f,
	8.5498797f, 13.3905183f, 8.5498797f, 16.0000000f, 8.5498797f, 18.7207544f, 8.5498797f, 21.5443469f,
	8.5498797f, 24.4637810f, 8.5498797f, 27.4731418f, 10.9027236f, 0.0000000f, 10.9027236f, 1.0000000f,
	10.9027236f, 2.5198421f, 10.9027236f, 4.3267487f, 10.9027236f, 6.3496042f, 10.9027236f, 8.5498797f,
	10.9027236f, 10.9027236f, 10.9027236f, 13.3905183f, 10.9027236f, 16.0000000f, 10.9027236f, 18.7207544f,
	10.9027236f, 21.5443469f, 10.9027236f, 24.4637810f, 10.9027236f, 27.4731418f, 13.3905183f, 0.0000000f,
	13.3905183f, 1.0000000f, 13.3905183f, 2.5198421f, 13.3905183f, 4.3267487f, 13.3905183f, 6.3496042f,
	13.3905183f, 8.5498797f, 13.3905183f, 10.9027236f, 13.3905183f, 13.3905183f, 13.3905183f, 16.0000000f,
	13.3905183f, 18.7207544f, 13.3905183f, 21.5443469f, 13.3905183f, 24.4637810f, 13.3905183f, 27.4731418f,
	16.0000000f, 0.0000000f, 16.0000000f, 1.0000000f, 16.0000000f, 2.5198421f, 16.0000000f, 4.3267487f,
	16.0000000f, 6.3496042f, 16.0000000f, 8.5498797f, 16.0000000f, 10.9027236f, 16.0000000f, 13.3905183f,
	16.0000000f, 16.0000000f, 16.0000000f, 18.7207544f, 16.0000000f, 21.5443469f, 16.0000000f, 24.4637810f,
	16.0000000f, 27.4731418f, 18.7207544f, 0.0000000f, 18.7207544f, 1.0000000f, 18.7207544f, 2.5198421f,
	18.7207544f, 4.3267487f, 18.7207544f, 6.3496042f, 18.7207544f, 8.5498797f, 18.7207544f, 10.9027236f,
	18.7207544f, 13.3905183f, 18.7207544f, 16.0000000f, 18.7207544f, 18.7207544f, 18.7207544f, 21.5443469f,
	18.7207544f, 24.4637810f, 18.7207544f, 27.4731418f, 21.5443469f, 0.0000000f, 21.5443469f, 1.0000000f,
	21.5443469f, 2.5198421f, 21.5443469f, 4.3267487f, 21.5443469f, 6.3496042f, 21.5443469f, 8.5498797f,
	21.5443469f, 10.9027236f, 21.5443469f, 13.3905183f, 21.5443469f, 16.0000000f, 21.5443469f, 18.7207544f,
	21.5443469f, 21.5443469f, 21.5443469f, 24.4637810f, 21.5443469f, 27.4731418f, 24.4637810f, 0.0000000f,
	24.4637810f, 1.0000000f, 24.4637810f, 2.5198421f, 24.4637810f, 4.3267487f, 24.4637810f, 6.3496042f,
	24.4637810f, 8.5498797f, 24.4637810f, 10.9027236f, 24.4637810f, 13.3905183f, 24.4637810f, 16.0000000f,
	24.4637810f, 18.7207544f, 24.4637810f, 21.5443469f, 24.4637810f, 24.4637810f, 24.4637810f, 27.4731418f,
	27.4731418f, 0.0000000f, 27.4731418f, 1.0000000f, 27.4731418f, 2.5198421f, 27.4731418f, 4.3267487f,
	27.4731418f, 6.3496042f, 27.4731418f, 8.5498797f, 27.4731418f, 10.9027236f, 27.4731418f, 13.3905183f,
	27.4731418f, 16.0000000f, 27.4731418f, 18.7207544f, 27.4731418f, 21.5443469f, 27.4731418f, 24.4637810f,
	27.4731418f, 27.4731418f,
};

static const float s_aac_codebook_vector_10[578] = {
	0.0000000f, 0.0000000f, 0.0000000f, 1.0000000f, 0.0000000f, 2.5198421f, 0.0000000f, 4.3267487f,
	0.0000000f, 6.3496042f, 0.0000000f, 8.5498797f, 0.0000000f, 10.9027236f, 0.0000000f, 13.3905183f,
	0.0000000f, 16.0000000f, 0.0000000f, 18.7207544f, 0.0000000f, 21.5443469f, 0.0000000f, 24.4637810f,
	0.0000000f, 27.4731418f, 0.0000000f, 30.5673509f, 0.0000000f, 33.7419917f, 0.0000000f, 36.9931811f,
	0.0000000f, 64.0000000f, 1.0000000f, 0.0000000f, 1.0000000f, 1.0000000f, 1.0000000f, 2.5198421f,
	1.0000000f, 4.3267487f, 1.0000000f, 6.3496042f, 1.0000000f, 8.5498797f, 1.0000000f, 10.9027236f,
	1.0000000f, 13.3905183f, 1.0000000f, 16.0000000f, 1.0000000f, 18.7207544f, 1.0000000f, 21.5443469f,
	1.0000000f, 24.4637810f, 1.0000000f, 27.4731418f, 1.0000000f, 30.5673509f, 1.0000000f, 33.7419917f,
	1.0000000f, 36.9931811f, 1.0000000f, 64.0000000f, 2.5198421f, 0.0000000f, 2.5198421f, 1.0000000f,
	2.5198421f, 2.5198421f, 2.5198421f, 4.3267487f, 2.5198421f, 6.3496042f, 2.5198421f, 8.5498797f,
	2.5198421f, 10.9027236f, 2.5198421f, 13.3905183f, 2.5198421f, 16.0000000f, 2.5198421f, 18.7207544f,
	2.5198421f, 21.5443469f, 2.5198421f, 24.4637810f, 2.5198421f, 27.4731418f, 2.5198421f, 30.5673509f,
	2.5198421f, 33.7419917f, 2.5198421f, 36.9931811f, 2.5198421f, 64.0000000f, 4.3267487f, 0.0000000f,
	4.3267487f, 1.0000000f, 4.3267487f, 2.5198421f, 4.3267487f, 4.3267487f, 4.3267487f, 6.3496042f,
	4.3267487f, 8.5498797f, 4.3267487f, 10.9027236f, 4.3267487f, 13.3905183f, 4.3267487f, 16.0000000f,
	4.3267487f, 18.7207544f, 4.3267487f, 21.5443469f, 4.3267487f, 24.4637810f, 4.3267487f, 27.4731418f,
	4.3267487f, 30.5673509f, 4.3267487f, 33.7419917f, 4.3267487f, 36.9931811f, 4.3267487f, 64.0000000f,
	6.3496042f, 0.0000000f, 6.3496042f, 1.0000000f, 6.3496042f, 2.5198421f, 6.3496042f, 4.3267487f,
	6.3496042f, 6.3496042f, 6.3496042f, 8.5498797f, 6.3496042f, 10.9027236f, 6.3496042f, 13.3905183f,
	6.3496042f, 16.0000000f, 6.3496042f, 18.7207544f, 6.3496042f, 21.5443469f, 6.3496042f, 24.4637810f,
	6.3496042f, 27.4731418f, 6.3496042f, 30.5673509f, 6.3496042f, 33.7419917f, 6.3496042f, 36.9931811f,
	6.3496042f, 64.0000000f, 8.5498797f, 0.0000000f, 8.5498797f, 1.0000000f, 8.5498797f, 2.5198421f,
	8.5498797f, 4.3267487f, 8.5498797f, 6.3496042f, 8.5498797f, 8.5498797f, 8.5498797f, 10.9027236f,
	8.5498797f, 13.3905183f, 8.5498797f, 16.0000000f, 8.5498797f, 18.7207544f, 8.5498797f, 21.5443469f,
	8.5498797f, 24.4637810f, 8.5498797f, 27.4731418f, 8.5498797f, 30.5673509f, 8.5498797f, 33.7419917f,
	8.5498797f, 36.9931811f, 8.5498797f, 64.0000000f, 10.9027236f, 0.0000000f, 10.9027236f, 1.0000000f,
	10.9027236f, 2.5198421f, 10.9027236f, 4.3267487f, 10.9027236f, 6.3496042f, 10.9027236f, 8.5498797f,
	10.9027236f, 10.9027236f, 10.9027236f, 13.3905183f, 10.9027236f, 16.0000000f, 10.9027236f, 18.7207544f,
	10.9027236f, 21.5443469f, 10.9027236f, 24.4637810f, 10.9027236f, 27.4731418f, 10.9027236f, 30.5673509f,
	10.9027236f, 33.7419917f, 10.9027236f, 36.9931811f, 10.9027236f, 64.0000000f, 13.3905183f, 0.0000000f,
	13.3905183f, 1.0000000f, 13.3905183f, 2.5198421f, 13.3905183f, 4.3267487f, 13.3905183f, 6.3496042f,
	13.3905183f, 8.5498797f, 13.3905183f, 10.9027236f, 13.3905183f, 13.3905183f, 13.3905183f, 16.0000000f,
	13.3905183f, 18.7207544f, 13.3905183f, 21.5443469f, 13.3905183f, 24.4637810f, 13.3905183f, 27.4731418f,
	13.3905183f, 30.5673509f, 13.3905183f, 33.7419917f, 13.3905183f, 36.9931811f, 13.3905183f, 64.0000000f,
	16.0000000f, 0.0000000f, 16.0000000f, 1.0000000f, 16.0000000f, 2.5198421f, 16.0000000f, 4.3267487f,
	16.0000000f, 6.3496042f, 16.0000000f, 8.5498797f, 16.0000000f, 10.9027236f, 16.0000000f, 13.3905183f,
	16.0000000f, 16.0000000f, 16.0000000f, 18.7207544f, 16.0000000f, 21.5443469f, 16.0000000f, 24.4637810f,
	16.0000000f, 27.4731418f, 16.0000000f, 30.5673509f, 16.0000000f, 33.7419917f, 16.0000000f, 36.9931811f,
	16.0000000f, 64.0000000f, 18.7207544f, 0.0000000f, 18.7207544f, 1.0000000f, 18.7207544f, 2.5198421f,
	18.7207544f, 4.3267487f, 18.7207544f, 6.3496042f, 18.7207544f, 8.5498797f, 18.7207544f, 10.9027236f,
	18.7207544f, 13.3905183f, 18.7207544f, 16.0000000f, 18.7207544f, 18.7207544f, 18.7207544f, 21.5443469f,
	18.7207544f, 24.4637810f, 18.7207544f, 27.4731418f, 18.7207544f, 30.5673509f, 18.7207544f, 33.7419917f,
	18.7207544f, 36.9931811f, 18.7207544f, 64.0000000f, 21.5443469f, 0.0000000f, 21.5443469f, 1.0000000f,
	21.5443469f, 2.5198421f, 21.5443469f, 4.3267487f, 21.5443469f, 6.3496042f, 21.5443469f, 8.5498797f,
	21.5443469f, 10.9027236f, 21.5443469f, 13.3905183f, 21.5443469f, 16.0000000f, 21.5443469f, 18.7207544f,
	21.5443469f, 21.5443469f, 21.5443469f, 24.4637810f, 21.5443469f, 27.4731418f, 21.5443469f, 30.5673509f,
	21.5443469f, 33.7419917f, 21.5443469f, 36.9931811f, 21.5443469f, 64.0000000f, 24.4637810f, 0.0000000f,
	24.4637810f, 1.0000000f, 24.4637810f, 2.5198421f, 24.4637810f, 4.3267487f, 24.4637810f, 6.3496042f,
	24.4637810f, 8.5498797f, 24.4637810f, 10.9027236f, 24.4637810f, 13.3905183f, 24.4637810f, 16.0000000f,
	24.4637810f, 18.7207544f, 24.4637810f, 21.5443469f, 24.4637810f, 24.4637810f, 24.4637810f, 27.4731418f,
	24.4637810f, 30.5673509f, 24.4637810f, 33.7419917f, 24.4637810f, 36.9931811f, 24.4637810f, 64.0000000f,
	27.4731418f, 0.0000000f, 27.4731418f, 1.0000000f, 27.4731418f, 2.5198421f, 27.4731418f, 4.3267487f,
	27.4731418f, 6.3496042f, 27.4731418f, 8.5498797f, 27.4731418f, 10.9027236f, 27.4731418f, 13.3905183f,
	27.4731418f, 16.0000000f, 27.4731418f, 18.7207544f, 27.4731418f, 21.5443469f, 27.4731418f, 24.4637810f,
	27.4731418f, 27.4731418f, 27.4731418f, 30.5673509f, 27.4731418f, 33.7419917f, 27.4731418f, 36.9931811f,
	27.4731418f, 64.0000000f, 30.5673509f, 0.0000000f, 30.5673509f, 1.0000000f, 30.5673509f, 2.5198421f,
	30.5673509f, 4.3267487f, 30.5673509f, 6.3496042f, 30.5673509f, 8.5498797f, 30.5673509f, 10.9027236f,
	30.5673509f, 13.3905183f, 30.5673509f, 16.0000000f, 30.5673509f, 18.7207544f, 30.5673509f, 21.5443469f,
	30.5673509f, 24.4637810f, 30.5673509f, 27.4731418f, 30.5673509f, 30.5673509f, 30.5673509f, 33.7419917f,
	30.5673509f, 36.9931811f, 30.5673509f, 64.0000000f, 33.7419917f, 0.0000000f, 33.7419917f, 1.0000000f,
	33.7419917f, 2.5198421f, 33.7419917f, 4.3267487f, 33.7419917f, 6.3496042f, 33.7419917f, 8.5498797f,
	33.7419917f, 10.9027236f, 33.7419917f, 13.3905183f, 33.7419917f, 16.0000000f, 33.7419917f, 18.7207544f,
	33.7419917f, 21.5443469f, 33.7419917f, 24.4637810f, 33.7419917f, 27.4731418f, 33.7419917f, 30.5673509f,
	33.7419917f, 33.7419917f, 33.7419917f, 36.9931811f, 33.7419917f, 64.0000000f, 36.9931811f, 0.0000000f,
	36.9931811f, 1.0000000f, 36.9931811f, 2.5198421f, 36.9931811f, 4.3267487f, 36.9931811f, 6.3496042f,
	36.9931811f, 8.5498797f, 36.9931811f, 10.9027236f, 36.9931811f, 13.3905183f, 36.9931811f, 16.0000000f,
	36.9931811f, 18.7207544f, 36.9931811f, 21.5443469f, 36.9931811f, 24.4637810f, 36.9931811f, 27.4731418f,
	36.9931811f, 30.5673509f, 36.9931811f, 33.7419917f, 36.9931811f, 36.9931811f, 36.9931811f, 64.0000000f,
	64.0000000f, 0.0000000f, 64.0000000f, 1.0000000f, 64.0000000f, 2.5198421f, 64.0000000f, 4.3267487f,
	64.0000000f, 6.3496042f, 64.0000000f, 8.5498797f, 64.0000000f, 10.9027236f, 64.0000000f, 13.3905183f,
	64.0000000f, 16.0000000f, 64.0000000f, 18.7207544f, 64.0000000f, 21.5443469f, 64.0000000f, 24.4637810f,
	64.0000000f, 27.4731418f, 64.0000000f, 30.5673509f, 64.0000000f, 33.7419917f, 64.0000000f, 36.9931811f,
	64.0000000f, 64.0000000f,
};

// Dispatch tables: codebook number -> code words, lengths, size, values.
static const uint16_t* const s_aac_spectral_codes[11] = {
	s_aac_spectral_codes_1, s_aac_spectral_codes_2, s_aac_spectral_codes_3, s_aac_spectral_codes_4, s_aac_spectral_codes_5, s_aac_spectral_codes_6, s_aac_spectral_codes_7, s_aac_spectral_codes_8, s_aac_spectral_codes_9, s_aac_spectral_codes_10, s_aac_spectral_codes_11,
};
static const uint8_t* const s_aac_spectral_bits[11] = {
	s_aac_spectral_bits_1, s_aac_spectral_bits_2, s_aac_spectral_bits_3, s_aac_spectral_bits_4, s_aac_spectral_bits_5, s_aac_spectral_bits_6, s_aac_spectral_bits_7, s_aac_spectral_bits_8, s_aac_spectral_bits_9, s_aac_spectral_bits_10, s_aac_spectral_bits_11,
};
static const uint16_t s_aac_spectral_sizes[11] = {
	81, 81, 81, 81, 81, 81, 64, 64, 169, 169, 289,
};
static const float* const s_aac_codebook_vectors[11] = {
	s_aac_codebook_vector_0, s_aac_codebook_vector_0, s_aac_codebook_vector_2, s_aac_codebook_vector_2, s_aac_codebook_vector_4, s_aac_codebook_vector_4, s_aac_codebook_vector_6, s_aac_codebook_vector_6, s_aac_codebook_vector_8, s_aac_codebook_vector_8, s_aac_codebook_vector_10,
};

// Scalefactor band offsets for a 48 kHz long window: 49 bands, ISO/IEC 14496-3 Table 4.73.
static const uint16 swb_offset_48000_1024[50] = {
	0, 4, 8, 12, 16, 20, 24, 28, 32, 36, 40, 48, 56, 64, 72, 80, 88, 96, 108, 120,
	132, 144, 160, 176, 196, 216, 240, 264, 292, 320, 352, 384, 416, 448, 480, 512,
	544, 576, 608, 640, 672, 704, 736, 768, 800, 832, 864, 896, 928, 1024
};

static inline float aac_fabs(float x) {
	return (x < 0.0f) ? -x : x;
}

static inline float aac_pow2_quarter(int exp_quarter) {
	int n = exp_quarter >> 2;
	int rem = exp_quarter & 3;
	static const float rem_table[4] = { 1.0f, 1.189207115f, 1.414213562f, 1.681792831f };
	float base = rem_table[rem];
	if (n >= 0) {
		while (n > 30) { base *= 1073741824.0f; n -= 30; }
		return base * (float)(1ULL << n);
	} else {
		int neg_n = -n;
		while (neg_n > 30) { base /= 1073741824.0f; neg_n -= 30; }
		return base / (float)(1ULL << neg_n);
	}
}

static inline float aac_pow43(float val) {
	if (val <= 0.0f) return 0.0f;
	if (val == 1.0f) return 1.0f;
	static const float pow43_small[17] = {
		0.000000f, 1.000000f, 2.519842f, 4.326749f,
		6.349604f, 8.549880f, 10.902724f, 13.390518f,
		16.000000f, 18.720754f, 21.544347f, 24.463781f,
		27.473142f, 30.567343f, 33.741992f, 36.993181f,
		40.317474f
	};
	int ival = (int)(val + 0.5f);
	if (ival >= 0 && ival <= 16 && (float)ival == val) {
		return pow43_small[ival];
	}
	double r = 4.0;
	for (int iter = 0; iter < 6; ++iter) {
		r = (2.0 * r + (double)val / (r * r)) / 3.0;
	}
	return (float)((double)val * r);
}

struct AACBitReader {
	const uint8* buf;
	size_t len;
	size_t bit_pos;
};

static inline void AACBitReader_Init(AACBitReader* br, const uint8* buf, size_t len) {
	br->buf = buf;
	br->len = len;
	br->bit_pos = 0;
}

static inline uint32 AACBitReader_GetBits(AACBitReader* br, int n) {
	if (n <= 0) return 0;
	uint32 val = 0;
	for (int i = 0; i < n; ++i) {
		size_t byte_idx = br->bit_pos >> 3;
		int bit_idx = 7 - (int)(br->bit_pos & 7);
		int bit = 0;
		if (byte_idx < br->len) {
			bit = (br->buf[byte_idx] >> bit_idx) & 1;
			br->bit_pos++;
		} else {
			br->bit_pos = br->len * 8;
		}
		val = (val << 1) | bit;
	}
	return val;
}

static inline int AACBitReader_Get1Bit(AACBitReader* br) {
	size_t byte_idx = br->bit_pos >> 3;
	int bit_idx = 7 - (int)(br->bit_pos & 7);
	int bit = 0;
	if (byte_idx < br->len) {
		bit = (br->buf[byte_idx] >> bit_idx) & 1;
		br->bit_pos++;
	} else {
		br->bit_pos = br->len * 8;
	}
	return bit;
}

static inline size_t AACBitReader_BitsLeft(const AACBitReader* br) {
	size_t total_bits = br->len * 8;
	return (br->bit_pos < total_bits) ? (total_bits - br->bit_pos) : 0;
}

static inline uint32 AACBitReader_PeekBits(AACBitReader* br, int n) {
	size_t save = br->bit_pos;
	uint32 val = AACBitReader_GetBits(br, n);
	br->bit_pos = save;
	return val;
}

static inline void AACBitReader_SkipBits(AACBitReader* br, int n) {
	br->bit_pos += n;
}

static int AAC_DecodeHuffman(AACBitReader* br, const uint16_t* codes, const uint8_t* bits, int size) {
	for (int i = 0; i < size; ++i) {
		int b = bits[i];
		if (b > 0) {
			uint32 peek = AACBitReader_PeekBits(br, b);
			if (peek == codes[i]) {
				AACBitReader_SkipBits(br, b);
				return i;
			}
		}
	}
	return -1;
}

static int AAC_DecodeScalefactor(AACBitReader* br) {
	for (int i = 0; i < 121; ++i) {
		int b = s_aac_scalefactor_bits[i];
		if (b > 0) {
			uint32 peek = AACBitReader_PeekBits(br, b);
			if (peek == s_aac_scalefactor_code[i]) {
				AACBitReader_SkipBits(br, b);
				return i - 60;
			}
		}
	}
	return 0;
}

// Half windows of the four AAC window shapes (ISO/IEC 14496-3 4.6.11.3.2), indexed by
// window_shape: 0 is the sine window, 1 the Kaiser-Bessel derived window.  Only the sine
// window used to exist here, while real streams almost always signal window_shape = 1.
static float aac_win_long[2][1024];
static float aac_win_short[2][128];
static float aac_frame_win[2048];
static float aac_cos_lut[8192];
static bool aac_win_inited = false;

// Kaiser-Bessel derived window (ISO/IEC 14496-3 4.6.11.3.2): the
// normalised running sum of a Kaiser window, with I0 evaluated as a truncated series.
static void AAC_KbdWindow(float* window, double alpha, int n) {
	const double pi = 3.14159265358979323846;
	const double alpha2 = (alpha * pi / n) * (alpha * pi / n);
	double sum = 0.0;
	for (int i = 0; i < n; ++i) {
		const double tmp = (double)i * (n - i) * alpha2;
		double bessel = 1.0;
		for (int j = 50; j > 0; --j) bessel = bessel * tmp / ((double)j * j) + 1.0;
		sum += bessel;
		window[i] = (float)sum;
	}
	sum += 1.0;
	for (int i = 0; i < n; ++i) window[i] = (float)dblsqrt((double)window[i] / sum);
}

static void InitAACWindow() {
	if (aac_win_inited) return;
	const double pi = 3.14159265358979323846;
	for (int i = 0; i < 1024; ++i) aac_win_long[0][i] = (float)dblsin(pi / 2048.0 * (i + 0.5));
	for (int i = 0; i < 128; ++i) aac_win_short[0][i] = (float)dblsin(pi / 256.0 * (i + 0.5));
	AAC_KbdWindow(aac_win_long[1], 4.0, 1024);
	AAC_KbdWindow(aac_win_short[1], 6.0, 128);
	/* Precompute discrete cosine LUT for 2048-point IMDCT:
	 * ISO/IEC 14496-3 Clause 4.5.2.8.2:
	 * Angle theta(n, k) = (2*pi / N) * (n + 0.5 + N/4) * (k + 0.5)
	 * For N = 2048: theta(n, k) = (pi / 4096) * (2n + 1025) * (2k + 1).
	 * Period 2*pi corresponds to 8192 discrete angle bins. */
	for (int i = 0; i < 8192; ++i) {
		aac_cos_lut[i] = (float)dblcos(2.0 * pi / 8192.0 * (double)i);
	}
	aac_win_inited = true;
}

// Assemble the 2048-sample analysis window of one frame from the two half windows.  A start or
// stop sequence splices a short window into an otherwise flat half, which is what lets a long
// block abut the eight short ones.
static void AAC_BuildFrameWindow(int win_seq, int win_shape) {
	const float* L = aac_win_long[win_shape & 1];
	const float* S = aac_win_short[win_shape & 1];
	if (win_seq == 1) {                          // LONG_START_SEQUENCE
		for (int i = 0; i < 1024; ++i) aac_frame_win[i] = L[i];
		for (int i = 1024; i < 1472; ++i) aac_frame_win[i] = 1.0f;
		for (int i = 0; i < 128; ++i) aac_frame_win[1472 + i] = S[127 - i];
		for (int i = 1600; i < 2048; ++i) aac_frame_win[i] = 0.0f;
	} else if (win_seq == 3) {                   // LONG_STOP_SEQUENCE
		for (int i = 0; i < 448; ++i) aac_frame_win[i] = 0.0f;
		for (int i = 0; i < 128; ++i) aac_frame_win[448 + i] = S[i];
		for (int i = 576; i < 1024; ++i) aac_frame_win[i] = 1.0f;
		for (int i = 1024; i < 2048; ++i) aac_frame_win[i] = L[2047 - i];
	} else {                                     // ONLY_LONG_SEQUENCE
		for (int i = 0; i < 1024; ++i) {
			aac_frame_win[i] = L[i];
			aac_frame_win[2047 - i] = L[i];
		}
	}
}

/* ISO/IEC 14496-3 Clause 4.5.2.8.2: IMDCT synthesis for N = 2048
 * x_n = (2 / N) * sum_{k=0}^{N/2 - 1} X_k * cos((2*pi/N)*(n + 0.5 + N/4)*(k + 0.5))
 * Normalization factor (2 / N) = (2 / 2048) = (1 / 1024). */
static void AAC_IMDCT_2048(const float* in, float* out) {
	const int N = 2048;
	const int N2 = 1024;
	const float inv_N = 1.0f / 1024.0f; // 2.0 / N = 2.0 / 2048 = 1.0 / 1024

	for (int n = 0; n < N; ++n) {
		float sum = 0.0f;
		int step = 2 * n + 1025;
		int idx = step & 8191;
		int step2 = (step * 2) & 8191;
		for (int k = 0; k < N2; ++k) {
			sum += in[k] * aac_cos_lut[idx];
			idx = (idx + step2) & 8191;
		}
		out[n] = sum * inv_N;
	}
}

// Temporal noise shaping (ISO/IEC 14496-3 4.6.9).  The filters are parsed with the side
// information and applied to the spectrum after mid/side decoding and before the filterbank,
// which is where the decoder applies them: after mid/side, before the filterbank.
struct AACTnsFilter {
	int length;
	int order;
	int direction;
	int coef_compress;
	int coef[32];
};

struct AACTns {
	int n_filt;
	int coef_res;
	AACTnsFilter filt[8];
};

// Transmitted filter coefficients -> LPC coefficients (ISO/IEC 14496-3 4.6.9.3, tns_decode_coef).
static void AAC_TnsDecodeCoef(int order, int coef_res_bits, int coef_compress,
							  const int* coef, float* a) {
	static const int sgn_mask[3] = { 0x2, 0x4, 0x8 };
	static const int neg_mask[3] = { ~0x3, ~0x7, ~0xf };
	int tmp[32];
	float tmp2[32];
	float b[32];

	const int coef_res2 = coef_res_bits - coef_compress;
	const int s_mask = sgn_mask[coef_res2 - 2];
	const int n_mask = neg_mask[coef_res2 - 2];
	const double half_pi = 1.57079632679489661923;
	const double iqfac = ((double)(1 << (coef_res_bits - 1)) - 0.5) / half_pi;
	const double iqfac_m = ((double)(1 << (coef_res_bits - 1)) + 0.5) / half_pi;

	for (int i = 0; i < order; ++i) {
		tmp[i] = (coef[i] & s_mask) ? (coef[i] | n_mask) : coef[i];
		tmp2[i] = (float)dblsin(tmp[i] / ((tmp[i] >= 0) ? iqfac : iqfac_m));
	}

	a[0] = 1.0f;
	for (int m = 1; m <= order; ++m) {
		for (int i = 1; i < m; ++i) b[i] = a[i] + tmp2[m - 1] * a[m - i];
		for (int i = 1; i < m; ++i) a[i] = b[i];
		a[m] = tmp2[m - 1];
	}
}

// y(n) = x(n) - lpc[1]*y(n-1) - ... - lpc[order]*y(n-order); the state starts at zero and the
// result overwrites the input (ISO/IEC 14496-3 4.6.9.3, tns_ar_filter).
static void AAC_TnsArFilter(float* spectrum, int size, int inc, const float* lpc, int order) {
	float y[32];
	if (order > 32) order = 32;
	for (int i = 0; i < order; ++i) y[i] = 0.0f;
	int idx = 0;
	for (int n = 0; n < size; ++n, idx += inc) {
		float x = spectrum[idx];
		for (int k = 0; k < order; ++k) x -= lpc[k + 1] * y[k];
		for (int k = order - 1; k > 0; --k) y[k] = y[k - 1];
		y[0] = x;
		spectrum[idx] = x;
	}
}

static void AAC_TnsApply(float* spec, const AACTns* tns, int max_sfb) {
	// The long window of 48 kHz has 49 scalefactor bands; AAC-LC allows TNS over at most
	// TNS_MAX_BANDS = 40 of them and filter orders up to TNS_MAX_ORDER = 12 (ISO/IEC 14496-3
	// Tables 4.102 and 4.103).
	const int kNumSwb = 49;
	const int kMaxBands = 40;
	const int kMaxOrder = 12;
	int bottom = kNumSwb;
	for (int f = 0; f < tns->n_filt; ++f) {
		const AACTnsFilter& flt = tns->filt[f];
		int top = bottom;
		bottom = top - flt.length;
		if (bottom < 0) bottom = 0;
		int order = flt.order;
		if (order > kMaxOrder) order = kMaxOrder;
		if (order <= 0) continue;

		float lpc[32];
		AAC_TnsDecodeCoef(order, tns->coef_res + 3, flt.coef_compress, flt.coef, lpc);

		int b = bottom, t = top;
		if (b > kMaxBands) b = kMaxBands;
		if (t > kMaxBands) t = kMaxBands;
		if (b > max_sfb) b = max_sfb;
		if (t > max_sfb) t = max_sfb;
		int start = swb_offset_48000_1024[b];
		int end = swb_offset_48000_1024[t];
		int size = end - start;
		if (size <= 0) continue;

		int inc = 1;
		if (flt.direction) { inc = -1; start = end - 1; }
		AAC_TnsArFilter(spec + start, size, inc, lpc, order);
	}
}

struct AACChannelState {
	float overlap[1024];
};

struct AACDecoderState {
	AACChannelState ch[2];
};

static bool DecodeAAC_CPE(
	AACDecoderState* state,
	const uint8* data,
	size_t len,
	int16* pcm_out_interleaved
) {
	InitAACWindow();
	AACBitReader br;
	AACBitReader_Init(&br, data, len);

	int id = AACBitReader_GetBits(&br, 3);
	if (id != 1) return false;

	int tag = AACBitReader_GetBits(&br, 4);
	int common_win = AACBitReader_Get1Bit(&br);
	if (!common_win) return false;

	// ics_info (ISO/IEC 14496-3 Table 4.6).  A reserved bit precedes window_sequence, and a long
	// window carries predictor_data_present after max_sfb; skipping either one shifted every
	// following field by a bit and made the whole frame decode into noise.
	AACBitReader_Get1Bit(&br);                       // ics_reserved_bit
	int win_seq = AACBitReader_GetBits(&br, 2);
	int win_shape = AACBitReader_Get1Bit(&br);
	if (win_seq == 2) return false;                  // eight short windows, not implemented
	int max_sfb = AACBitReader_GetBits(&br, 6);
	// swb_offset_48000_1024 describes 49 long scalefactor bands, so swb_offsets[s + 1] would run
	// past the table for anything larger.
	if (max_sfb <= 0 || max_sfb > 49) return false;
	if (AACBitReader_Get1Bit(&br)) return false;     // predictor_data_present (AAC Main / LTP only)

	int ms_mask_present = AACBitReader_GetBits(&br, 2);
	uint8 ms_used[128] = { 0 };
	if (ms_mask_present == 1) {
		for (int sfb = 0; sfb < max_sfb; ++sfb) {
			ms_used[sfb] = AACBitReader_Get1Bit(&br);
		}
	} else if (ms_mask_present == 2) {
		for (int sfb = 0; sfb < max_sfb; ++sfb) ms_used[sfb] = 1;
	}

	uint8 sect_cb[2][128] = { 0 };
	int16 sf[2][128] = { 0 };
	float spec[2][1024] = { 0 };
	AACTns tns[2] = {};

	const uint16* swb_offsets = swb_offset_48000_1024;

	for (int ch = 0; ch < 2; ++ch) {
		int global_gain = AACBitReader_GetBits(&br, 8);
		int sfb = 0;
		while (sfb < max_sfb) {
			if (br.bit_pos >= br.len * 8) return false;
			int cb = AACBitReader_GetBits(&br, 4);
			int incr = 0;
			int len_code = 0;
			while ((len_code = AACBitReader_GetBits(&br, 5)) == 31) {
				incr += 31;
				if (br.bit_pos >= br.len * 8) return false;
			}
			incr += len_code;
			if (incr <= 0) return false;
			for (int k = 0; k < incr && sfb < max_sfb; ++k, ++sfb) {
				sect_cb[ch][sfb] = (uint8)cb;
			}
		}

		// Scalefactors are three independent differential chains: normal codebooks, noise bands
		// and intensity bands each have their own accumulator, and the first noise band sends its
		// gain as a plain 9-bit preamble instead of a code word (ISO/IEC 14496-3 4.6.3.3;
		// offset[3] and NOISE_PRE).  Feeding noise and intensity gains into the normal chain
		// shifted every later scalefactor, which is what made the level of a frame depend on how
		// many noise or intensity bands happened to precede it.
		int cur_sf = global_gain;
		int noise_sf = global_gain;
		int intensity_sf = 0;
		bool noise_seen = false;
		for (int s = 0; s < max_sfb; ++s) {
			int band = sect_cb[ch][s];
			if (band == 0) {
				sf[ch][s] = 0;
				continue;
			}
			if (band == 13) {                   // NOISE_BT
				noise_sf += noise_seen
					? AAC_DecodeScalefactor(&br)
					: ((int)AACBitReader_GetBits(&br, 9) - 256);
				noise_seen = true;
				sf[ch][s] = (int16)noise_sf;
				continue;
			}
			if (band == 14 || band == 15) {     // INTENSITY_BT2 / INTENSITY_BT
				intensity_sf += AAC_DecodeScalefactor(&br);
				sf[ch][s] = (int16)intensity_sf;
				continue;
			}
			cur_sf += AAC_DecodeScalefactor(&br);
			sf[ch][s] = (int16)cur_sf;
		}

		int pulse_present = AACBitReader_Get1Bit(&br);
		if (pulse_present) {
			int pulse_num = AACBitReader_GetBits(&br, 2);
			int pulse_start_sfb = AACBitReader_GetBits(&br, 6);
			for (int p = 0; p <= pulse_num; ++p) {
				AACBitReader_GetBits(&br, 5);
				AACBitReader_GetBits(&br, 4);
			}
		}

		int tns_present = AACBitReader_Get1Bit(&br);
		if (tns_present) {
			// Every filter of the window is coded, and each coefficient loses a bit when
			// coef_compress is set (coef_len = coef_res + 3 - coef_compress, ISO/IEC 14496-3
			// Table 4.48).  Reading a single filter with a fixed coefficient width
			// over-consumed the bitstream whenever n_filt > 1 or a filter was compressed,
			// desynchronising the rest of the frame.
			int n_filt = AACBitReader_GetBits(&br, 2);
			int coef_res = n_filt ? AACBitReader_Get1Bit(&br) : 0;
			tns[ch].n_filt = n_filt;
			tns[ch].coef_res = coef_res;
			for (int filt = 0; filt < n_filt; ++filt) {
				AACTnsFilter& flt = tns[ch].filt[filt];
				flt.length = (int)AACBitReader_GetBits(&br, 6);
				flt.order = (int)AACBitReader_GetBits(&br, 5);
				flt.direction = 0;
				flt.coef_compress = 0;
				if (flt.order > 0) {
					flt.direction = (int)AACBitReader_Get1Bit(&br);
					flt.coef_compress = (int)AACBitReader_Get1Bit(&br);
					int coef_bits = coef_res + 3 - flt.coef_compress;
					int n = flt.order;
					if (n > 32) n = 32;
					for (int o = 0; o < n; ++o) {
						flt.coef[o] = (int)AACBitReader_GetBits(&br, coef_bits);
					}
				}
			}
		}

		int gain_present = AACBitReader_Get1Bit(&br);
		if (gain_present) {
			AACBitReader_GetBits(&br, 2);
		}

		for (int s = 0; s < max_sfb; ++s) {
			int cb = sect_cb[ch][s];
			int sfb_start = swb_offsets[s];
			int sfb_end = swb_offsets[s + 1];
			int sfb_lines = sfb_end - sfb_start;

			if (cb == 0 || cb > 11) {
				for (int k = 0; k < sfb_lines && (sfb_start + k) < 1024; ++k) spec[ch][sfb_start + k] = 0.0f;
				continue;
			}

			const uint16_t* codes = s_aac_spectral_codes[cb - 1];
			const uint8_t* bits = s_aac_spectral_bits[cb - 1];
			int size = s_aac_spectral_sizes[cb - 1];
			const float* vecs = s_aac_codebook_vectors[cb - 1];
			int dim = (cb <= 4) ? 4 : 2;

			float scale = aac_pow2_quarter(sf[ch][s] - 100);

			for (int k = 0; k < sfb_lines; k += dim) {
				if (br.bit_pos >= br.len * 8) break;
				int idx = AAC_DecodeHuffman(&br, codes, bits, size);
				// Substituting index 0 here used to hide a desynchronised bit reader and turn
				// it into plausible-looking noise; a code word that cannot be matched means the
				// frame is not decodable at this point.
				if (idx < 0) return false;

				// An unsigned codebook writes the sign bits of the whole tuple before the escape
				// sequences, the order ISO/IEC 14496-3 4.6.3.3 prescribes: code word, then the
				// sign bits, then the escapes.  The escape is marked by the sentinel 64.0f in the
				// codebook vectors, not by the value 16.0f.  Interleaving sign bits with the
				// escapes, and testing 16.0f, left 64.0f in the spectrum as a real coefficient
				// (64^(4/3) = 256, which is exactly the oversized magnitude seen here) and
				// desynchronised everything after it.
				bool neg[4] = { false, false, false, false };
				if (cb == 3 || cb == 4 || (cb >= 7 && cb <= 11)) {
					for (int d = 0; d < dim; ++d) {
						if (vecs[idx * dim + d] != 0.0f) {
							neg[d] = (AACBitReader_Get1Bit(&br) != 0);
						}
					}
				}

				for (int d = 0; d < dim; ++d) {
					float mag = aac_fabs(vecs[idx * dim + d]);
					// The codebook vector tables already hold |q|^(4/3), so the inverse
					// quantization of a coded coefficient is just its table value.  Only the ESC
					// codebook's escape word carries a raw magnitude, and that one still needs the
					// 4/3 power.  Applying it to the table values as well scaled every band by a
					// factor that grew with the coefficient, which is what pushed the output 44%
					// above the reference level.
					bool escaped = false;
					if (cb == 11 && mag == 64.0f) {
						int n_ones = 0;
						while (AACBitReader_BitsLeft(&br) > 0 && AACBitReader_Get1Bit(&br) == 1) {
							// The escape sequence is at most 11111111 0 + 12 bits, so more
							// consecutive ones than that mean the reader is already off track.
							if (++n_ones > 8) return false;
						}
						if (AACBitReader_BitsLeft(&br) < (size_t)(n_ones + 4)) return false;
						int esc = AACBitReader_GetBits(&br, n_ones + 4);
						mag = (float)((1 << (n_ones + 4)) + esc);
						escaped = true;
					}

					float iq = (escaped ? aac_pow43(mag) : mag) * scale;
					if (neg[d]) iq = -iq;
					if (sfb_start + k + d < 1024) {
						spec[ch][sfb_start + k + d] = iq;
					}
				}
			}
		}
	}

	for (int s = 0; s < max_sfb; ++s) {
		if (ms_used[s]) {
			int sfb_start = swb_offsets[s];
			int sfb_end = swb_offsets[s + 1];
			for (int i = sfb_start; i < sfb_end; ++i) {
				float L = spec[0][i];
				float R = spec[1][i];
				spec[0][i] = L + R;
				spec[1][i] = L - R;
			}
		}
	}

	// Temporal noise shaping is the last thing applied to the spectrum before the filterbank
	// (ISO/IEC 14496-3 4.6.9.3).  It was parsed but never applied, so every frame that used it
	// came out with the wrong spectral envelope.
	for (int ch = 0; ch < 2; ++ch) {
		if (tns[ch].n_filt > 0) AAC_TnsApply(spec[ch], &tns[ch], (int)max_sfb);
	}

	// The IMDCT output is windowed with the shape and sequence this frame signalled.
	AAC_BuildFrameWindow(win_seq, win_shape);

	for (int ch = 0; ch < 2; ++ch) {
		float time_buf[2048];
		AAC_IMDCT_2048(spec[ch], time_buf);

		for (int i = 0; i < 2048; ++i) {
			time_buf[i] *= aac_frame_win[i];
		}

		for (int i = 0; i < 1024; ++i) {
			float sample = time_buf[i] + state->ch[ch].overlap[i];
			state->ch[ch].overlap[i] = time_buf[i + 1024];

			// The IMDCT above carries the 2/N of ISO/IEC 14496-3, so its output already is the
			// reconstructed time signal on the same scale as the coded PCM.  Scaling it by 32767
			// a second time saturated every non-silent frame.
			int pcm = (int)(sample);
			if (pcm < -32768) pcm = -32768;
			if (pcm > 32767) pcm = 32767;
			pcm_out_interleaved[i * 2 + ch] = (int16)pcm;
		}
	}

	return true;
}

	// Raw AAC access units carry no framing of their own, so the stream walks the frame table of
	// the container that owns them.  One access unit decodes to 1024 interleaved stereo samples.
	class AACStream : public uni::IAudioStream {
	private:
		uni::StorageTrait* m_storage;
		uni::trait::Malloc* m_alloc;
		const uni::AACRawFrame* m_frames;
		uint32 m_frame_count;
		uint32 m_frame_cap;
		bool   m_owns_frames;
		uint32 m_curr_frame;
		uni::AudioInfo m_info;

		AACDecoderState m_state;
		int16 m_pcm[2048];
		uint32 m_pcm_avail;
		uint32 m_pcm_off;

		byte* m_packet;
		uint32 m_packet_cap;

		bool LoadFrame(uint32 index) {
			if (index >= m_frame_count || !m_frames) return false;
			const uni::AACRawFrame& f = m_frames[index];
			if (f.size == 0) return false;
			if (f.size > m_packet_cap) {
				byte* bigger = (byte*)m_alloc->allocate(f.size, 3);
				if (!bigger) return false;
				if (m_packet) m_alloc->deallocate(m_packet, m_packet_cap);
				m_packet = bigger;
				m_packet_cap = f.size;
			}
			return StorageReadExact(*m_storage, f.offset, m_packet, f.size);
		}

	public:
		AACStream(
			uni::StorageTrait& storage,
			const uni::AACRawFrame* frames,
			uint32 frame_count,
			uint32 frame_cap,
			bool own_frames,
			uint32 sample_rate,
			uint32 channels,
			uni::trait::Malloc& allocator
		) : m_storage(&storage), m_alloc(&allocator), m_frames(frames), m_frame_count(frame_count),
			m_frame_cap(frames ? frame_cap : 0), m_owns_frames(own_frames), m_curr_frame(0),
			m_pcm_avail(0), m_pcm_off(0), m_packet(nullptr), m_packet_cap(0) {
			MemSet(&m_state, 0, sizeof(m_state));
			m_info = uni::AudioInfo{};
			m_info.format.sample_format = uni::AudioSampleFormat::S16LE;
			m_info.format.channels = (uint16)(channels ? channels : 2);
			m_info.format.sample_rate = sample_rate;
			m_info.containerFormat = uni::AudioContainerFormat::AAC;
			m_info.bitsPerSample = 16;
			m_info.totalSamples = frame_count * 1024;
			m_info.durationMs = sample_rate
				? (uint32)(((uint64)frame_count * 1024 * 1000) / sample_rate)
				: 0;
		}

		virtual void Release() override {
			uni::trait::Malloc* alloc = m_alloc;
			uint32 cap = m_frame_cap;
			const uni::AACRawFrame* frames = m_frames;
			bool owned = m_owns_frames;
			byte* packet = m_packet;
			uint32 packet_cap = m_packet_cap;
			this->~AACStream();
			if (packet) alloc->deallocate(packet, packet_cap);
			if (owned && frames) alloc->deallocate((void*)frames, cap * sizeof(uni::AACRawFrame));
			alloc->deallocate(this);
		}

		virtual uni::AudioResult GetInfo(uni::AudioInfo& outInfo) const override {
			outInfo = m_info;
			return uni::AudioResult::OK;
		}

		virtual uni::AudioResult ReadSamples(void* destBuffer, uint32 maxBytes, uint32& bytesRead) override {
			bytesRead = 0;
			if (!destBuffer || maxBytes == 0) return uni::AudioResult::InvalidArgument;

			byte* out = (byte*)destBuffer;
			while (maxBytes > 0) {
				if (m_pcm_avail > 0) {
					uint32 to_copy = (maxBytes < m_pcm_avail) ? maxBytes : m_pcm_avail;
					MemCopyN(out, (byte*)m_pcm + m_pcm_off, to_copy);
					out += to_copy;
					bytesRead += to_copy;
					maxBytes -= to_copy;
					m_pcm_off += to_copy;
					m_pcm_avail -= to_copy;
					continue;
				}
				if (m_curr_frame >= m_frame_count) break;

				uint32 size = m_frames[m_curr_frame].size;
				// A rejected access unit becomes silence instead of a short read, so one bad
				// frame cannot shift the whole stream out of step with the video.
				bool ok = LoadFrame(m_curr_frame) && DecodeAAC_CPE(&m_state, m_packet, size, m_pcm);
				if (!ok) MemSet(m_pcm, 0, 1024 * 2 * sizeof(int16));
				++m_curr_frame;
				m_pcm_avail = 1024 * 2 * sizeof(int16);
				m_pcm_off = 0;
			}
			if (bytesRead == 0 && m_curr_frame >= m_frame_count) return uni::AudioResult::EndOfStream;
			return uni::AudioResult::OK;
		}

		virtual uni::AudioResult Seek(uint32 sampleIndex) override {
			uint32 frame = sampleIndex / 1024;
			if (frame > m_frame_count) frame = m_frame_count;
			m_curr_frame = frame;
			m_pcm_avail = 0;
			m_pcm_off = 0;
			// The overlap held from the previous frame belongs to the old position.
			MemSet(&m_state, 0, sizeof(m_state));
			return uni::AudioResult::OK;
		}
	};

	static const char* const AAC_EXTENSIONS[] = { ".aac", ".adts", nullptr };

	// ADTS frame header (ISO/IEC 13818-7): 12-bit sync word, then the sampling frequency index
	// and channel configuration.  Every frame carries 1024 samples in the LC profile handled here.
	static bool AAC_ParseADTSHeader(const byte* h, uint32& sample_rate, uint32& channels, uint32& frame_len) {
		if (!h || h[0] != 0xFF || (h[1] & 0xF0) != 0xF0) return false;
		static const uint32 rates[16] = {
			96000, 88200, 64000, 48000, 44100, 32000, 24000, 22050,
			16000, 12000, 11025, 8000, 7350, 0, 0, 0
		};
		sample_rate = rates[(uint32)(h[2] >> 2) & 0x0F];
		if (sample_rate == 0) return false;
		channels = ((uint32)(h[2] & 0x01) << 2) | ((uint32)(h[3] >> 6) & 0x03);
		frame_len = ((uint32)(h[3] & 0x03) << 11) | ((uint32)h[4] << 3) | ((uint32)(h[5] >> 5) & 0x07);
		return frame_len >= 7;
	}

} // namespace

namespace uni {

	IAudioStream* AAC_OpenRawStream(
		StorageTrait& storage,
		const AACRawFrame* frames,
		uint32 frame_count,
		uint32 sample_rate,
		uint32 channels,
		trait::Malloc& allocator
	) {
		if (!frames || frame_count == 0 || sample_rate == 0) return nullptr;
		void* mem = allocator.allocate(sizeof(AACStream), 3);
		if (!mem) return nullptr;
		// The caller owns the table: MP4 keeps it for its sample-to-time mapping.
		return new (mem) AACStream(storage, frames, frame_count, 0, false,
								   sample_rate, channels, allocator);
	}

	const char* AACCodec::GetName() const { return "AAC"; }

	AudioContainerFormat AACCodec::GetFormat() const { return AudioContainerFormat::AAC; }

	const char* const* AACCodec::GetExtensions() const { return AAC_EXTENSIONS; }

	AudioResult AACCodec::Probe(StorageTrait& storage, bool& matched) const {
		matched = false;
		byte h[7];
		if (!StorageReadExact(storage, 0, h, sizeof(h))) return AudioResult::IoError;
		uint32 rate = 0, channels = 0, frame_len = 0;
		if (!AAC_ParseADTSHeader(h, rate, channels, frame_len)) return AudioResult::OK;
		matched = true;
		return AudioResult::OK;
	}

	AudioResult AACCodec::ReadInfo(StorageTrait& storage, AudioInfo& outInfo) const {
		byte h[7];
		if (!StorageReadExact(storage, 0, h, sizeof(h))) return AudioResult::IoError;
		uint32 rate = 0, channels = 0, frame_len = 0;
		if (!AAC_ParseADTSHeader(h, rate, channels, frame_len)) return AudioResult::InvalidFormat;
		outInfo = AudioInfo{};
		outInfo.format.sample_format = AudioSampleFormat::S16LE;
		outInfo.format.channels = (uint16)(channels ? channels : 2);
		outInfo.format.sample_rate = rate;
		outInfo.bitsPerSample = 16;
		outInfo.containerFormat = AudioContainerFormat::AAC;
		return AudioResult::OK;
	}

	AudioResult AACCodec::OpenStream(
		StorageTrait& storage,
		IAudioStream*& outStream,
		trait::Malloc& allocator
	) const {
		outStream = nullptr;
		byte h[7];
		if (!StorageReadExact(storage, 0, h, sizeof(h))) return AudioResult::IoError;
		uint32 rate = 0, channels = 0, first_len = 0;
		if (!AAC_ParseADTSHeader(h, rate, channels, first_len)) return AudioResult::InvalidFormat;

		// Walk the ADTS chain once so the stream can be seeked by frame index.
		uint32 capacity = 1024;
		AACRawFrame* frames = (AACRawFrame*)allocator.allocate(capacity * sizeof(AACRawFrame), 3);
		if (!frames) return AudioResult::OutOfMemory;
		uint32 count = 0;
		uint64 pos = 0;
		for (;;) {
			byte fh[7];
			if (!StorageReadExact(storage, pos, fh, sizeof(fh))) break;
			uint32 r = 0, c = 0, len = 0;
			if (!AAC_ParseADTSHeader(fh, r, c, len)) break;
			if (count == capacity) {
				uint32 bigger_cap = capacity * 2;
				AACRawFrame* bigger = (AACRawFrame*)allocator.allocate(bigger_cap * sizeof(AACRawFrame), 3);
				if (!bigger) break;
				MemCopyN(bigger, frames, capacity * sizeof(AACRawFrame));
				allocator.deallocate(frames, capacity * sizeof(AACRawFrame));
				frames = bigger;
				capacity = bigger_cap;
			}
			// Skip the header: the decoder expects the raw access unit.
			frames[count].offset = pos + 7;
			frames[count].size = len - 7;
			++count;
			pos += len;
		}
		if (count == 0) {
			allocator.deallocate(frames, capacity * sizeof(AACRawFrame));
			return AudioResult::InvalidFormat;
		}

		void* mem = allocator.allocate(sizeof(AACStream), 3);
		if (!mem) {
			allocator.deallocate(frames, capacity * sizeof(AACRawFrame));
			return AudioResult::OutOfMemory;
		}
		// The table was built here, so the stream releases it with itself.
		outStream = new (mem) AACStream(storage, frames, count, capacity, true,
										rate, channels, allocator);
		return AudioResult::OK;
	}

} // namespace uni

#endif
