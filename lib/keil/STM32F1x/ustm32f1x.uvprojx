# Keil uVision project ustm32f1x.uvprojx, settings and files
target Library (6190000::V6.19::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ustm32f1 (library)
  c flags: Optim=3 OneElfS=1 uGnu=1 v6Lang=5 v6LangP=9 wLevel=3
  c define: _MCU_STM32F1x
  c misc: -fno-strict-aliasing -Wno-c++98-compat -Wno-old-style-cast -Wno-c++98-c++11-compat-binary-literal -Wno-extra-semi-stmt -Wno-deprecated-copy-with-user-provided-copy -Wno-c++98-compat-pedantic -Wno-keyword-macro -Wno-invalid-constexpr
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Embeded
    ../../../lib/cpp/Device/: GPIO.cpp RCC.cpp SysTick.cpp NVIC.cpp AFIO.cpp
    ../../../lib/cpp/Device/Interrupt/: interrupt_tab.cpp
    ../../../lib/cpp/: interrupt.cpp
    ../../cpp/Device/: ADC.cpp DAC.cpp DMA.cpp IIC.cpp SRAM.cpp TIM.cpp UART.cpp Power.cpp
    ../../cpp/MCU/: STM32F1.cpp
    ../../cpp/Device/GPIO/: GPIO-setMode.cpp
    ../../cpp/Device/RCC/: SysClock.cpp PLL.cpp Oscillator.cpp
