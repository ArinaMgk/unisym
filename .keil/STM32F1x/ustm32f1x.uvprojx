# Keil uVision project ustm32f1x.uvprojx, settings and files
target Library (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ustm32f1 (library)
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _MCU_STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Group
    ../../lib/cpp/Device/: GPIO.cpp RCC.cpp SysTick.cpp NVIC.cpp AFIO.cpp
    ../../lib/cpp/Device/Interrupt/: interrupt_tab.cpp
    ../../lib/cpp/: interrupt.cpp
