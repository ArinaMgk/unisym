# Keil uVision project umsp432p4.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: umsp432p4 (library)
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: _MCU_MSP432P4
  c misc: -Wno-covered-switch-default -Wno-old-style-cast -Wno-keyword-macro -Wno-c++98-compat -Wno-padded -Wno-global-constructors -Wno-exit-time-destructors
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Embedded
    ../../../lib/cpp/: interrupt.cpp
    ../../../lib/cpp/Device/Interrupt/: interrupt_tab.cpp
    ../../../lib/cpp/Device/: GPIO.cpp
    ../../cpp/MCU/: MSP432P4.cpp
    ../../cpp/Device/GPIO/: GPIO-setMode.cpp
    ../../cpp/Device/: Power.cpp SysTick.cpp
    ../../cpp/Device/RCC/: SysClock.cpp
