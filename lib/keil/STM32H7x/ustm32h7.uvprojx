# Keil uVision project ustm32h7.uvprojx, settings and files
target STM32H7 (6190000::V6.19::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ustm32h7 (library)
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=1
  c define: _MCU_STM32H7x, _HIS_IMPLEMENT, _MCCA=0x1A072032, _DEBUG
  c misc: -fno-strict-aliasing -Wno-c++98-compat -Wno-old-style-cast -Wno-c++98-c++11-compat-binary-literal -Wno-extra-semi-stmt -Wno-deprecated-copy-with-user-provided-copy -Wno-c++98-compat-pedantic -Wno-keyword-macro -Wno-invalid-constexpr -Wno-unknown-attributes -Wno-empty-body
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Embedded
    ../../cpp/Device/: DBG.cpp GPIO.cpp RCC.cpp Cache.cpp SysTick.cpp NVIC.cpp Power.cpp DMA.cpp Watchdog.cpp TIM.cpp ADC.cpp BDMA.cpp MDMA.cpp DAC.cpp VREFBUF.cpp AFIO.cpp
    ../../cpp/Device/RCC/: SysClock.cpp RealtimeClock.cpp
    ../../cpp/Device/Video/: LTDC.cpp GPU.cpp
  group General
    ../../cpp/: interrupt.cpp consio.cpp stream.cpp string.cpp color.cpp lock.cpp
    ../../c/: mcore.c arith.c debug.c
    ../../cpp/Device/: Video.cpp Video-VideoConsole.cpp Video-VCI.cpp
    ../../c/data/font/: font-8x5.c font-16x8.c
    ../../c/datime/: weekday.c
    ../../c/ustring/astring/: StrHeap.c salc.c StrHeapN.c
    ../../c/arith/: dct.c
    ../../cpp/Auxiliary/: TableToxxxer.cpp TableTrigo.cpp
    ../../cpp/Datype/: bstring.cpp
    ../../cpp/Datype/Charset/: Unicode.cpp
  group Submodule
    ../../cpp/Device/RCC/: PLL.cpp Oscillator.cpp RCC-setClock.cpp
    ../../cpp/Device/GPIO/: GPIO-setMode.cpp
    ../../cpp/Device/Interrupt/: interrupt_tab.cpp
  group Data
    ../../c/dnode/: dchain.c DnodeAppend.c DnodeBind.c DnodeChainAdapt.c DnodeCount.c DnodeGeneral.c DnodeIndex.c DnodeInsert.c DnodeRelease.c DnodeRemove.c DnodeRewind.c DnodeSort.c
    ../../cpp/Datype/dnode/: DnodeAppendX.cpp DnodeRemoveX.cpp
    ../../cpp/Datype/: dnode.cpp nnode.cpp
    ../../c/nnode/: NnodeInsert.c NnodeRelease.c
  group Locale
    ../../cpp/MCU/: STM32H7.cpp
  group Em_Engine
    ../../cpp/System/: Picture.cpp
    ../../cpp/Device/Graphic/: GPE-JPEG.cpp
    ../../cpp/Device/: RNG.cpp HASH.cpp CRC.cpp
    ../../cpp/Format/Picture/: JPEG.cpp PNG.cpp BMP.cpp
  group COMs
    ../../cpp/Device/: UART.cpp IIC.cpp I2S.cpp SAI.cpp SPI.cpp SPI-Quad.cpp FDCAN.cpp
    ../../cpp/Device/USB/: USB-Device.cpp HCD.cpp PCD.cpp OTGHostDevice.cpp USBPeri-Device.cpp USBPeri-MSC.cpp USBHost-MSC.cpp USBPeri-CDC.cpp USBHost-HID.cpp USBHost-Hub.cpp
  group Memory
    ../../cpp/Datype/: mempool.cpp
    ../../cpp/Device/: FMC.cpp SRAM.cpp
  group Storage
    ../../cpp/Device/: Storage.cpp Flash.cpp
    ../../cpp/Device/Storage/: Storage-GPT.cpp SDCard.cpp MMCard.cpp MMCard-Advanced.cpp MMCard-HAL_MMCEx_MultiBuffer.cpp
    ../../cpp/Device/Storage/SDCard/: SDCard-Callback.cpp SDCard-DMALinkedLists.cpp SDCard-GetCmdRespx.cpp SDCard-HAL_SD_ConfigSpeedBusOperation.cpp SDCard-HAL_SDEx_MultiBuffer.cpp SDCard-Others.cpp SDCard-RW.cpp SDCard-setMode.cpp SDCard-USE_SD_TRANSCEIVER.cpp
    ../../cpp/Device/Storage/FMC/: FMC-Flash-NAND.cpp FMC-Flash-NOR.cpp
  group FS
    ../../cpp/Format/Filesys/: FAT.cpp
    ../../cpp/Format/Filesys/FAT/: FAT-create.cpp FAT-remove.cpp FAT-rename.cpp FAT-truncate.cpp FAT-write.cpp
  group Music
    ../../cpp/System/Audiosys/: Resampler.cpp
    ../../cpp/Format/Audio/: WAV.cpp MP3.cpp FLAC.cpp
  group Movie
    ../../cpp/Format/Video/: AVI.cpp H264.cpp MPEG.cpp MPEG4.cpp
  group USBDev
    ../../cpp/Device/: Keyboard.cpp Mouse.cpp
  group Witch
    ../../cpp/Witch/: _TextChrome.cpp Form.cpp
