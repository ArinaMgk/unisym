# Keil uVision project ucw32f030.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: ucw32f030 (library)
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=2
  c define: _MCU_CW32F030
  c misc: -Wno-weak-vtables -Wno-old-style-cast -Wno-keyword-macro -Wno-c++98-compat -Wno-padded -Wno-global-constructors -Wno-exit-time-destructors
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Embedded
    ../../../lib/cpp/: interrupt.cpp
    ../../../lib/cpp/Device/Interrupt/: interrupt_tab.cpp
    ../../../lib/cpp/Device/: GPIO.cpp ADC.cpp AFIO.cpp DAC.cpp DMA.cpp IIC.cpp NVIC.cpp RCC.cpp SRAM.cpp SysTick.cpp TIM.cpp UART.cpp
    ../../cpp/MCU/: CW32F030.cpp
    ../../cpp/Device/GPIO/: GPIO-setMode.cpp
    ../../cpp/Device/RCC/: SysClock.cpp Oscillator.cpp PLL.cpp
    ../../cpp/Device/: Power.cpp
