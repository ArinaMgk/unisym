; ASCII AASM TAB4 LF
; ARM64 minimal integer, control-flow, and memory encoding coverage.

[ARCH arm64]
[BITS 64]

NOP
MOV X0, X1
MOV W2, 0x12345678
MOV X3, -1
ADD X4, X0, X1
ADD W5, W2, 16
ADDS X0, X1, X2
ADDS XZR, SP, 1
SUB X6, X4, 4096
SUBS X3, X4, 8
ADC X5, X6, X7
SBC W8, W9, W10
CMP X6, X4
CMP W5, 16
TST X0, X1
AND X7, X4, X6
ORR W8, W5, W2
EOR X9, X7, X6
MUL X11, X12, X13
SDIV X14, X15, X16
UDIV W17, W18, W19
LSL X20, X21, X22
LSR W23, W24, W25
ASR X26, X27, X28
ROR X29, X30, X0
STR X9, [SP + 16]
LDR X10, [SP + 16]
STRB W8, [SP + 1]
LDRB W11, [SP + 1]
LDRSB X12, [SP + 1]
MOV X13, BYTE [SP + 1]
MOV X14, SIGNED BYTE [SP + 1]
MOV BYT8 [SP + 24], X10
B.EQ equal
MOV W15, 0
equal:
BL call_target
JMP done
call_target:
RET
done:
CALL X10
BR X9
BLR X8
RET LR
LDR X0, [X1 - 8]
LDUR X2, [X3 + 1]
LDR X4, [X5 + X6, LSL 3]
STR X29, [SP - 16]!
LDP X29, X30, [SP], 16
