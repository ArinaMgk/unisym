# Keil uVision project ustm32f4.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ustm32f4 (library)
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _MCU_STM32F4x
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Embedded
    ../../lib/cpp/: interrupt.cpp
    ../../lib/cpp/MCU/: STM32F4.cpp
    ../../lib/cpp/Device/Interrupt/: interrupt_tab.cpp
    ../../lib/cpp/Device/: GPIO.cpp ADC.cpp AFIO.cpp DAC.cpp DMA.cpp IIC.cpp NVIC.cpp RCC.cpp SRAM.cpp SysTick.cpp TIM.cpp UART.cpp
  group Device
    ../../lib/cpp/Device/Video/: LCD1602.cpp
